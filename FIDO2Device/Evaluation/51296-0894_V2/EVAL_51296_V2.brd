# Repository diverta/onecard-fido

File README.md:

# セキュリティデバイス実装対応

最終更新日：2023/4/13

Nordic社のSoC「nRF5」にFIDO2認証機能等を実装するプロジェクトです。

## プログラム

- <b>[nRF52840アプリケーション](nRF52840_app)</b><br>
FIDO2認証機能、PIV／OpenPGPカードエミュレーション機能を実装したファームウェアです。<br>
Nordic社のSoC「nRF52840」で動作し、[MDBT50Q Dongle](FIDO2Device/MDBT50Q_Dongle)に書き込んで使用します。

- <b>[FIDO認証器管理ツール](MaintenanceTool)</b><br>
PC環境から、[FIDO認証器](FIDO2Device)の動作に必要な各種設定／動作テスト等を行う、デスクトップ・ツールです。<br>
[macOS版](MaintenanceTool/macOSApp/README.md)と、[Windows版](MaintenanceTool/dotNET/README.md)を用意しております。

- <b>[オープンソースコードライセンスについて](OSSL.md)</b><br>
上記プログラム内で使用されているオープンソースコード（ライブラリー）についての概要を掲載しています。

## ハードウェア

- <b>[MDBT50Q Dongle](FIDO2Device/MDBT50Q_Dongle)</b><br>
Nordic社のSoC「nRF52840」を使用したFIDO2認証器です。<br>
日本国内の技適取得済みであるnRF52840搭載モジュール「MDBT50Q」を使用し、nRF52840 Dongleとほぼ同じ仕様で製作しております。<br>
PCのUSBポート装着時はUSB HID／CCIDデバイスとして稼働し、ボタン乾電池装着時はBLEペリフェラルデバイスとして稼働します。

## What's new

#### 2023/04/13

FIDO認証器管理ツール（macOS版）の再構築が完了したので、エンドユーザー向けバンドル、ベンダー向けバンドルの両方を更新しました。<br>
また、MDBT50Q Dongle（rev2.2）で、ベンダー向け管理ツールによる鍵・証明書インストール時に確認された不具合を解消するため、nRF52840アプリケーションを修正いたしました。<br>
（これに伴い、FIDO認証器管理ツール（Windows版）も更新しています）<br>
詳細につきましては、ドキュメント<b>[「Release 202303」](https://github.com/diverta/onecard-fido/releases/tag/Release_202303)</b>をご参照願います。

#### 2023/02/08

FIDO認証器管理ツール（Windows版）の再構築が完了したので、エンドユーザー向けバンドル、ベンダー向けバンドルの両方を更新しました。<br>
また、MDBT50Q Dongle（rev2.2）で、ペアリング解除要求時に確認された不具合を解消するため、nRF52840アプリケーションを修正いたしました。<br>
（これに伴い、FIDO認証器管理ツール（macOS版）も更新しています）<br>
詳細につきましては、ドキュメント<b>[「Release 202302」](https://github.com/diverta/onecard-fido/releases/tag/Release_202302)</b>をご参照願います。

#### 2023/01/16

MDBT50Q Dongle（rev2.2）で新規搭載された機能を使用できるよう、nRF52840アプリケーションを修正いたしました。<br>
これに伴い、FIDO認証器管理ツール（macOS版）も更新いたしました<br>
詳細につきましては、ドキュメント<b>[「Release 202301」](https://github.com/diverta/onecard-fido/releases/tag/Release_202301)</b>をご参照願います。<br>
（Windows版管理ツールは再構築が必要となったため、しばらくの間ご利用いただけません。何卒ご容赦願います）

#### [過去の更新履歴はこちら](HISTORY.md)

## EAGLE design FIDO2Device/Evaluation/51296-0894_V2/EVAL_51296_V2.brd

Parts:
BAT1: BAT-HLD-012-SMT
CN1: 51296-0894
CN2: IF_6PIN; HEADER_6PIN
CN3: IF_3PIN; HEADER_3PIN
D1, D2: PMEG2005BELD,315; DFN1006D-2
D3: APHF1608LSEEQBDZGKC
Q1: BSS84AKQBZ; BSS84AKQB
R1: 5.1k; R0402N
R2: 20k; R0402N
R3, R4: 1.2k; R0402N
R5: 330; R0402N
R10, R11, R12, R13, R14: *; RESISTOR_0204_200MIL

Connections:
0V: BAT1.-, CN1.2; also elsewhere on the board
CLK: CN1.6, CN2.6
CS: CN1.8, CN2.4
D_C: CN1.4, CN2.2
LEDA: CN1.1, Q1.3 (D)
LED_B: CN3.3, R5.1, R14.1
LED_CTRL: CN2.1, R1.1, R10.1
LED_G: CN3.2, R4.1, R13.1
LED_R: CN3.1, R3.1, R12.1
MOSI: CN1.5, CN2.5
unnamed: Q1.1 (G), R1.2, R2.1, R10.2, R11.1
unnamed: BAT1.+@2 (+), D1.2 (A)
unnamed: D3.2 (CRED), R3.2, R12.2
unnamed: D3.4 (CGREEN), R4.2, R13.2
unnamed: D3.3 (CBLUE), R5.2, R14.2
RESET: CN1.3, CN2.3
VDD: CN1.7, D1.1 (C), D2.1 (C), D3.1 (A), Q1.2 (S), R2.2, R11.2; also elsewhere on the board
VDD_NRF: D2.2 (A); also elsewhere on the board

Notes on the sheet:
51296-0894 Evaluation board
Evaluation board for FPC connector
バックライト制御回路
LED_CTRLにLOWを出力すると バックライトが点灯します。
TFTモジュール接続用 FPCコネクター
TFTモジュール接続用 汎用I/O接続ポート
ピン対応 P1.09 --> 1 P1.10 --> 2 P1.11 --> 3 P1.12 --> 4 P1.13 --> 5 P1.15 --> 6
電源回路
VDD_NRFが電源に未接続の場合、 ボタン電池からVDD_に電源が 供給されます。
３色LED接続用 汎用I/O接続ポート
３色LED

Parts:
C1: 0.1uF; C0402N
CN4: IF_4PIN; HEADER_4PIN
R6, R7, R8, R9: 10k; R0402N
U1: RV-3028-C7; SON-8

Connections:
0V: C1.2, CN4.1, R8.1, R9.1, U1.5 (VSS); also elsewhere on the board
unnamed: R9.2, U1.6 (VBACKUP)
unnamed: R8.2, U1.8 (EVI)
TWI_SCL: CN4.3, R7.1, U1.3 (SCL)
TWI_SDA: CN4.2, R6.1, U1.4 (SDA)
VDD: C1.1, R6.2, R7.2, U1.7 (VDD); also elsewhere on the board
VDD_NRF: CN4.4; also elsewhere on the board

Notes on the sheet:
51296-0894 Evaluation board
Evaluation board for FPC connector
ピン対応 GND --> 1 SDA --> 2 SCL --> 3 VDD --> 4
RTCC回路接続用 汎用I/O接続ポート
RTCC回路

Board: 2 copper layers, 25.0 x 38.0 mm, 25 parts (0 on the bottom side), 22 nets.

File FIDO2Device/Evaluation/51296-0894_V2/bom/EVAL_51296_V2_BOM.csv:

,,,,,,,,
,,,EVAL_51296_V2 1PCS BOM  (Bill of Materials),,,,,
,,,,,,,,
,,,,,,,,
,,,,,,,,
Item #,*Ref Des,*Qty,Manufacturer,*Mfg Part #,Description / Value,*Package,Type,Your Instructions / Notes
1,BAT1,1,Linx Technologies,BAT-HLD-012-SMT,Coin Cell Battery Holder,,SMD,
2,C1,1,Taiyo Yuden,UMK105B7104KV-FR,0.1uF,"0402",SMD,
3,CN1,1,Molex,51296-0894,0.5mm-8pins FFC & FPC Connector,,SMD,
4,"D1, D2",2,Nexperia,"PMEG2005BELD,315",Schottky Rectifier,SOD882D,SMD,
5,D3,1,Kingbright,APHF1608LSEEQBDZGKC,1.6 x 0.8 mm Full-Color Surface Mount LED,"0603",SMD,
6,Q1,1,Nexperia,BSS84AKQBZ,P-Channel MOSFET,SOT8015,SMD,
7,R1,1,Vishay,CRCW04025K10FKEDC,"Resistor, 5.1k ohm 1% 1/16W","0402",SMD,
8,R2,1,Vishay,CRCW040220K0FKEDC,"Resistor, 20k ohm 1% 1/16W","0402",SMD,
9,"R3, R4",2,Vishay,CRCW04021K20FKEDC,"Resistor, 1.2k ohm 1% 1/16W","0402",SMD,
10,R5,1,Vishay,CRCW0402330RFKEDC,"Resistor, 330 ohm 1% 1/16W","0402",SMD,
11,"R6, R7, R8, R9",4,Vishay,CRCW040210K0JNEDC,"Resistor, 10k ohm 5% 1/16W","0402",SMD,
12,U1,1,Micro Crystal AG,RV-3028-C7 32.768kHz 1ppm TA QC,Real Time Clock 32.768kHz I2C Time Acc. 1ppm,SON-8,SMD,'RV-3028-C7 32.768kHz 1ppm TA QA' as alternative

## EAGLE design FIDO2Device/Evaluation/USB4155-03-C/EVAL_USB4155.brd

Parts:
CN1: USB4155-03-C
CN2: 87520-0010BLF
CN3: IF_5PIN_H; HEADER_5PIN
R1, R2: 5.1k; R0402N
R3: 0; R0402N

Connections:
0V: CN1.A1 (GND1), CN1.A12 (GND2), CN1.B1 (GND3), CN1.B12 (GND4), CN2.GND, CN3.1, R1.1, R2.1
CC_1: CN1.A5 (CC1), R1.2, R3.2
CC_2: CN1.B5 (CC2), R2.2, R3.1
DN_C: CN1.A7 (D_N1), CN1.B7 (D_N2), CN2.D-, CN3.2
DP_C: CN1.A6 (D_P1), CN1.B6 (D_P2), CN2.D+, CN3.3
FG_C: CN1.FG1, CN1.FG2, CN2.FG1, CN2.FG2, CN3.5
VBUS_C: CN1.A4 (VBUS1), CN1.A9 (VBUS2), CN1.B4 (VBUS3), CN1.B9 (VBUS4), CN2.VBUS, CN3.4

Notes on the sheet:
USB4155 Evaluation board
Evaluation board for USB-C Plug
【注意】 PCのUSBポートに装着時は、 R2、R3のどちらかを 撤去してください。

Board: 2 copper layers, 29.9 x 29.9 mm, 6 parts (0 on the bottom side), 7 nets.

File FIDO2Device/Evaluation/USB4155-03-C/bom/EVAL_USB4155_BOM.csv:

,,,,,,,,
,,,EVAL_USB4155 1PCS BOM  (Bill of Materials),,,,,
,,,,,,,,
,,,,,,,,
,,,,,,,,
Item #,*Ref Des,*Qty,Manufacturer,*Mfg Part #,Description / Value,*Package,Type,Your Instructions / Notes
1,CN1,1,Global Connector Technology,USB4155-03-C,USB Type-C plug,,SMD,
2,CN2,1,Amphenol ICC,87520-0010BLF,USB Type-A receptacle,,DIP,"If you could not purchase this part, no need to install."
3,"R1, R2",2,Vishay,CRCW04025K10FKEDC,"Resistor, 5.1k ohm 1% 1/16W",0402,SMD,
4,R3,1,Vishay,CRCW04020000Z0EDC,"Resistor, 0 ohm 1/16W",0402,SMD,

## EAGLE design FIDO2Device/MDBT50Q_Dongle/pcb_rev2_2/FIDO2AUTH_0022.brd

File FIDO2Device/MDBT50Q_Dongle/pcb_rev2_2/README.md:

# MDBT50Q Dongle（rev2.2）の概要

## 基板の概要

日本国内の技適取得済みであるnRF52840搭載モジュール「MDBT50Q」をそのまま使用し、USB回路、ユーザーインターフェース回路、外部電源回路を追加した、USBドングル基板です。

### 表面

### 裏面

## 動作の概要

### 電源と動作モード

２電源方式となっています（充電機能はありません）。<br>
PCのUSBポートへの装着状態で、動作モードが自動的に切り替わります。

#### USB HIDモード

PCのUSBポートに装着すると、USB HIDデバイスとして動作します。[注1][注2]<br>
アイドル時は緑色LEDが点滅します。

#### BLEペリフェラルモード（非ペアリングモード）

基板背面の電池ホルダーにボタン乾電池（CR1225）をセットすると、BLEペリフェラルデバイスとして動作します。[注2]<br>
アイドル時は青色LEDが点滅します。

#### BLEペリフェラルモード（ペアリングモード）

MDBT50Q Dongleがペアリングされていない場合、または非ペアリングモードでボタンを３秒以上長押しすると、ペアリングモードに遷移します。[注3]<br>
下図のように、ペアリングモードであることを示す、橙色LEDが連続点灯します。

[注1] ボタン乾電池がセットされていない場合は、PCのUSBから電源を取得し、USB HIDデバイスとして動作します。<br>
[注2] ボタン乾電池がセットされている状態でも、PCのUSBポートに装着している間は、常にUSB HIDデバイスとして動作します。<br>
[注3] [管理ツール](../../../MaintenanceTool/README.md)を使用し、macOS、Windowsとのペアリングができるようになります。<br>

#### USB CDCモード（ブートローダーモード）

[管理ツール](../../../MaintenanceTool/README.md)から「ファームウェア更新」を実行すると、ブートローダーモードに遷移し、ファームウェアが転送可能な状態となります。<br>
下図のように、橙色LEDと緑色LEDが同時に点灯します。

### LED点灯制御

基板上に４点のLEDが配置されています。

各LEDの点灯制御は以下の通りです。

|LED |LEDの色 |点灯制御 |動作モード |アプリケーションの状態 |
|:-|:-:|:-:|:-:|:-|
|LED1|橙 |連続点灯|BLE|ペアリングモード時|
|LED1|橙 |通常点滅|BLE|ペアリング情報の無効を検知時[注1]|
|LED1|橙 |高速点滅|BLE|ペアリング情報の消失を検知時[注2]|
|LED2|赤 |連続点灯|USB HID／BLE|アプリケーションハング時／ビジー時[注3]|
|LED2|赤 |高速点滅|USB HID|リセットコマンド実行のためユーザー確認中[注4]|
|LED3|緑 |緩く点滅|USB HID|アイドル時（機能未実行または無通信時。以下同）|
|LED3|緑 |通常点滅|USB HID／BLE|ユーザー登録／ログイン実行のためのユーザー所在確認中[注5]|
|LED4|青 |緩く点滅|BLE|アイドル時|
|LED1/LED3|橙・緑 |連続点灯|USB CDC|ブートローダーモード時|
|LED2/LED3/LED4|赤・緑・青 |連続点灯|USB HID／BLE|クリティカルエラー発生時[注6]|

- 通常点滅＝秒間２回の点滅
- 高速点滅＝秒間５回の点滅
- 緩く点滅＝約２秒ごとに点滅

[注1] PC側のペアリング情報を環境設定画面から削除してしまった後、PCからMDBT50Q DongleのBLE機能を実行すると発生します。<br>
[注2] 管理ツールの「ペアリング情報削除」機能により、MDBT50Q Dongleからすべてのペアリング情報を消去した後、PC側に残存しているペアリング情報を使用して、再度ペアリングを試行すると発生します。<br>
[注3] アプリケーションハング時は、USB HIDモード時はPCのUSBポートからの抜き差し、BLEペリフェラルモード時はボタン電池の抜き差しにより、元のアイドル時に戻ります。<br>
[注4] [管理ツール](../../../MaintenanceTool/README.md)の「PINコード解除」機能実行時に発生します。<br>
[注5] WebAuthnのユーザー登録／ログイン時に発生します。<br>
[注6] FIDO2で規定するセキュリティー違反（例えば3回連続でPIN入力エラー）があった場合に発生します。赤色LED・緑色LED・青色LEDが同時点灯します。

### 電源オン制御

MDBT50Q Dongleの基板背面にある電池ホルダーに、ボタン乾電池（CR1225）をセットした当初は、スリープ状態となっております。<br>
基板上の全てのLEDは消灯しており、スリープ状態である事を示しています。

BLE経由で認証器の機能をご利用の際は、まずMDBT50Q Dongleをアイドル状態（PCからの要求を待ち受けている状態）に遷移させる必要があります。<br>
スリープ状態時に、基板上のボタンを１回押すと、アイドル状態に遷移し、青色LEDが点滅を開始します。[注1]

[注1] MDBT50Q Dongleがペアリングされていない場合は、ペアリングモードにおけるアイドル状態に遷移し、橙色LEDが連続点灯します。

### 電源オフ制御

MDBT50Q Dongleは、アイドル状態が３分程度続くと、自動的にスリープ状態に遷移します。<br>
これにより、LEDが消灯し、電池電源の消耗を防ぎます。

他方、アイドル状態時に、基板上のボタンを１回押すと、強制的にスリープ状態に遷移させることができます。[注1]

[注1]スリープ状態時に、基板上のボタンを１回押すと、再びアイドル状態に遷移し、青色LEDが点滅を開始（ペアリングモードの場合は橙色LEDが連続点灯）します。

Parts:
C1, C2: 12pF; C0603N
C3, C4: 4.7uF; C0603N
C5: 0.1uF; C0402N
P1, P2, P3, P4: 0; ROUND-MARK-1.0
R1: 10k; R0402N
SW1: SKRPACE010
SW2: SKTADAE010
U1: MDBT50Q-P1M
X1: NX3215SA-32.768K; NX3215

Connections:
0V: C1.2, C2.2, C3.2, C4.2, C5.2, SW1.3 (S), SW1.4 (S1), SW2.1, SW2.3 (P1), U1.1 (GND), U1.2 (GND), U1.15 (GND), U1.33 (GND), U1.55 (GND); also elsewhere on the board
D_N: U1.34 (D-); also elsewhere on the board
D_P: U1.35 (D+); also elsewhere on the board
LED1: U1.19 (P0.26); also elsewhere on the board
LED2: U1.23 (P0.07); also elsewhere on the board
LED3: U1.16 (P0.27); also elsewhere on the board
LED4: U1.29 (P0.12); also elsewhere on the board
RESET: C5.1, R1.2, SW2.2 (S), SW2.4 (S1), U1.40 (P0.18/RESET)
SW1: SW1.1, SW1.2 (P1), U1.57 (P1.06)
SWDCLK: U1.53 (SWDCLK); also elsewhere on the board
SWDIO: U1.51 (SWDIO); also elsewhere on the board
TWI_SCL: U1.11 (P0.02/AIN0); also elsewhere on the board
TWI_SDA: U1.22 (P0.06); also elsewhere on the board
TXD: U1.49 (P0.25); also elsewhere on the board
VBUS_NRF: C4.1, U1.32 (VBUS); also elsewhere on the board
VDD_NRF: C3.1, R1.1, U1.28 (VDD), U1.30 (VDDH); also elsewhere on the board
XL1: C1.1, U1.17 (P0.00/XL1), X1.1
XL2: C2.1, U1.18 (P0.01/XL2), X1.2

Notes on the sheet:
32.768kHzクリスタル
バイパスコンデンサー
Secure Dongle with nRF52840
MDBT50Q Dongle （rev2.2）
モジュール部
リセット回路
MAIN SW

Parts:
C6: 0.01uF; C0402N
C7, C8: 0.1uF; C0402N
C9: 10uF; C0603N
CN1: TE-1734028
CN2: IF_5PIN_H; HEADER_5PIN
D1: APTD1608LSECK/J4-PF; APTD1608
D2: APHD1608LSURCK; APTD1608
D3: APTD1608LZGCK; APTD1608
D4: APTD1608LVBC/D; APTD1608
D5: PRTR5V0U2X; SOT143B
L1, L2, L3: BLM15AG121SN1D; C0402N
R2, R3: 1.2k; R0402N
R4: 1.5K; R0402N
R5: 390; R0402N

Connections:
0V: C6.2, C7.2, C8.2, C9.2, CN2.1, D5.1 (GND), L2.2, L3.2; also elsewhere on the board
D_N: CN1.2 (D-), D5.2 (I/O_1); also elsewhere on the board
D_P: CN1.3 (D+), D5.3 (I/O_2); also elsewhere on the board
LED1: R2.1; also elsewhere on the board
LED2: R3.1; also elsewhere on the board
LED3: R4.1; also elsewhere on the board
LED4: R5.1; also elsewhere on the board
unnamed: D4.C, R5.2
unnamed: CN1.4 (GND), L2.1
unnamed: CN1.FG1, CN1.FG2, L3.1
unnamed: D3.C, R4.2
unnamed: D2.C, R3.2
unnamed: D1.C, R2.2
SWDCLK: CN2.4; also elsewhere on the board
SWDIO: CN2.3; also elsewhere on the board
TXD: CN2.5; also elsewhere on the board
VBUS: C6.1, C8.1, C9.1, CN1.1 (VBUS), D5.4 (VCC), L1.1
VBUS_NRF: C7.1, L1.2; also elsewhere on the board
VDD_NRF: CN2.2, D1.A, D2.A, D3.A, D4.A; also elsewhere on the board

Notes on the sheet:
USBプラグ部
LED部
プログラミングI/F部
nRF52840アプリケーションを 書込する際に使用します。
LED（黄色）
LED（赤色）
LED（緑色）
LED（青色）
Secure Dongle with nRF52840
MDBT50Q Dongle （rev2.2）

Parts:
BAT1: BAT-HLD-012-SMT
C10, C11: 1uF; C0603N
C12: 0.1uF; C0402N
D6, D7: PMEG2005AEA,115; SOD323-W
R6, R7, R8, R9: 10k; R0402N
U2: XC6206P302MR-G; SOT23
U3: RV-3028-C7; SON-8

Connections:
0V: BAT1.-, C10.2, C11.2, C12.2, R8.1, R9.1, U2.1 (VSS), U3.5 (VSS); also elsewhere on the board
unnamed: C11.1, D6.A, U2.2 (VOUT)
unnamed: BAT1.+@2 (+), D7.A
unnamed: R9.2, U3.6 (VBACKUP)
unnamed: R8.2, U3.8 (EVI)
TWI_SCL: R7.1, U3.3 (SCL); also elsewhere on the board
TWI_SDA: R6.1, U3.4 (SDA); also elsewhere on the board
VBUS_NRF: C10.1, U2.3 (VIN); also elsewhere on the board
VDD_NRF: C12.1, D6.C, D7.C, R6.2, R7.2, U3.7 (VDD); also elsewhere on the board

Notes on the sheet:
電源供給部
USBポートに装着時は、VBUSの5.0V-->3.0Vに降圧して供給します。 乾電池ホルダーにボタン乾電池を装着した場合は、3.0Vを供給します。
ボタン乾電池ケースは 基板の背面に実装
時刻同期部
ボタン乾電池を装着すると、常時給電されます。
Secure Dongle with nRF52840
MDBT50Q Dongle （rev2.2）

Board: 2 copper layers, 69.5 x 69.5 mm, 44 parts (1 on the bottom side), 29 nets.

## EAGLE design FIDO2Device/MDBT53_Dongle/pcb_rev0/EVALBOARD_001.brd

File FIDO2Device/MDBT53_Dongle/README.md:

# [開発中] MDBT53 Dongle（rev1）

## 概要

日本国内の技適取得済みであるnRF5340搭載モジュール「MDBT53」を使用して製作する、USBドングル基板です。<br>
（下図は[MDBT50Q Dongle](../../FIDO2Device/MDBT50Q_Dongle)。ただし、MDBT53 Dongleもほぼ同イメージになる想定）

### 特色
- 外形寸法＝5cm x 2cm
- FIDO2機能（WebAuthn）をサポート
- FIDO2機能はUSB HID／BLEの両トランスポートをサポート
- USB給電／ボタン電池の２電源方式
- リアルタイムクロック・カレンダーを搭載し、電池装着時は時刻同期が可能
- 署名検証機能付きUSBブートローダーを採用し、不正ファームウェアの書込みを抑止
- CCIDインターフェースを装備し、PIV/OpenPGP/OATHカードエミュレーションが可能

### [nRF5340アプリケーション](../../nRF5340_app/README.md)

MDBT53 Dongleで使用するファームウェアです。

### [ファームウェア更新手順](../../MaintenanceTool/macOSApp/UPDATEFW_BLE.md)

MDBT53 Dongleのファームウェアを、[FIDO認証器管理ツール（macOS版）](../../MaintenanceTool/macOSApp)により更新する手順について説明しています。

## 動作確認手順

### [Edgeブラウザーを使用したWebAuthnテスト手順（Windows10 PC）](WEBAUTHNTEST.md)

MDBT53 Dongleと、Edgeブラウザー、デモサイトを使用して、WebAuthnのユーザー登録／ログイン（MakeCredential／GetAssertion）の動作確認をする場合の手順を掲載しています。

### [Googleアカウントのログイン確認手順（PC）](PCCHROME.md)

MDBT53 Dongleと、Googleアカウント、Chromeブラウザーを使用して、U2F Register／Authenticateの動作確認をする場合の手順を掲載しています。

### [PIN番号を使用したmacOSログイン確認手順](../../CCID/PIV/PIVPINLOGIN.md)

MDBT53 Dongleに設定したPIV機能を使用し、PIN番号によるmacOSログインを行うための確認手順を掲載しています。

Parts:
C1, C2: 12pF; C0603K
SW1: SKRPACE010
SW2: SKTADAE010
U1: MDBT53
X1: NX3215SA-32.768K-STD-MUA-9; NX3215

Connections:
0V: C1.2, C2.2, SW1.3 (S), SW1.4 (S1), SW2.2 (S), SW2.4 (S1), U1.1 (GND), U1.24 (GND), U1.42 (GND), U1.61 (GND); also elsewhere on the board
DCC: U1.54 (DCC); also elsewhere on the board
DCCD: U1.50 (DCCD); also elsewhere on the board
DCCH: U1.40 (DCCH); also elsewhere on the board
DECD: U1.52 (DECD); also elsewhere on the board
DECR: U1.58 (DECR); also elsewhere on the board
D_N: U1.48 (D-); also elsewhere on the board
D_P: U1.46 (D+); also elsewhere on the board
LED1: U1.60 (P0.28/AIN7); also elsewhere on the board
LED2: U1.65 (P0.29); also elsewhere on the board
LED3: U1.57 (P0.30); also elsewhere on the board
LED4: U1.56 (P0.31); also elsewhere on the board
RESET: SW2.1, SW2.3 (P1), U1.6 (RESET); also elsewhere on the board
SCL: U1.31 (P1.03/TWI); also elsewhere on the board
SDA: U1.33 (P1.02/TWI); also elsewhere on the board
SW1: SW1.1, SW1.2 (P1), U1.62 (P0.23)
SWDCLK: U1.2 (SWDCLK); also elsewhere on the board
SWDIO: U1.4 (SWDIO); also elsewhere on the board
TXD: U1.13 (P0.20); also elsewhere on the board
VBUS_NRF: U1.44 (VBUS); also elsewhere on the board
VDDH: U1.41 (VDDH); also elsewhere on the board
VDD_NRF: U1.38 (VDD); also elsewhere on the board
XL1: C1.1, U1.34 (P0.00/XL1), X1.1
XL2: C2.1, U1.36 (P0.01/XL2), X1.2

Notes on the sheet:
Eval board for MDBT53 Dongle
MDBT53 Dongle （rev0）
32.768kHzクリスタル
リセット回路
MAIN SW
モジュール部

Parts:
C3: 0.01uF; C0402K
C4, C5: 0.1uF; C0402K
C6: 10uF; C0603K
C7: 4.7uF; C0603K
CN1: USB4105-GF-A
CN2: IF_6PIN; HEADER_6PIN
D1: PRTR5V0U2X; SOT143B
L1, L2, L3: BLM15AG121SN1D; C0402K
R1, R2: 5.1k; R0402
R3: 2.2; R0402

Connections:
0V: C3.2, C4.2, C5.2, C6.2, C7.2, CN2.1, D1.1 (GND), L2.2, L3.2; also elsewhere on the board
D_N: CN1.A7 (D_N1), CN1.B7 (D_N2), D1.2 (I/O_1); also elsewhere on the board
D_P: CN1.A6 (D_P1), CN1.B6 (D_P2), D1.3 (I/O_2); also elsewhere on the board
FG: CN1.FG1, CN1.FG2, CN1.FG3, CN1.FG4, L3.1
unnamed: CN1.A5 (CC1), R1.2
unnamed: CN1.B5 (CC2), R2.2
RESET: CN2.5; also elsewhere on the board
SWDCLK: CN2.4; also elsewhere on the board
SWDIO: CN2.3; also elsewhere on the board
TXD: CN2.6; also elsewhere on the board
USB_GND: CN1.A1 (GND1), CN1.B1 (GND2), L2.1, R1.1, R2.1
VBUS: C3.1, C5.1, C6.1, CN1.A4 (VBUS1), CN1.B4 (VBUS2), D1.4 (VCC), L1.1
VBUS_CONN: C4.1, L1.2, R3.1; also elsewhere on the board
VBUS_NRF: C7.1, R3.2; also elsewhere on the board
VDD_NRF: CN2.2; also elsewhere on the board

Notes on the sheet:
Eval board for MDBT53 Dongle
MDBT53 Dongle （rev0）
USBコネクター部
USB-Cメス コネクターを 実装
プログラミングI/F部
nRF5340アプリケーションを 書込する際に使用します。

Parts:
C8: 0.1uF; C0402K
CN3: IF_7PIN; HEADER_7PIN
LED1: APTD1608LSECK/J4-PF; APTD1608
LED2: APHD1608LSURCK; APTD1608
LED3: APTD1608LZGCK; APTD1608
LED4: APTD1608LVBC/D; APTD1608
R4, R5: 1.2k; R0402
R6: 1.8k; R0402
R7: 390; R0402
R8, R9, R10, R11: 10k; R0402
U3: RV-3028-C7; SON-8

Connections:
0V: C8.2, CN3.1, R10.1, R11.1, U3.5 (VSS); also elsewhere on the board
DCC: CN3.3; also elsewhere on the board
DCCD: CN3.5; also elsewhere on the board
DCCH: CN3.6; also elsewhere on the board
DECD: CN3.4; also elsewhere on the board
DECR: CN3.2; also elsewhere on the board
LED1: R4.1; also elsewhere on the board
LED2: R5.1; also elsewhere on the board
LED3: R6.1; also elsewhere on the board
LED4: R7.1; also elsewhere on the board
unnamed: LED4.C, R7.2
unnamed: LED3.C, R6.2
unnamed: LED2.C, R5.2
unnamed: LED1.C, R4.2
unnamed: R11.2, U3.6 (VBACKUP)
unnamed: R10.2, U3.8 (EVI)
SCL: R9.1, U3.3 (SCL); also elsewhere on the board
SDA: R8.1, U3.4 (SDA); also elsewhere on the board
VDD_NRF: C8.1, CN3.7, LED1.A, LED2.A, LED3.A, LED4.A, R8.2, R9.2, U3.7 (VDD); also elsewhere on the board

Notes on the sheet:
LED部
LED（黄色）
LED（赤色）
LED（緑色）
LED（青色）
Eval board for MDBT53 Dongle
MDBT53 Dongle （rev0）
時刻同期部
ボタン乾電池を装着すると、常時給電されます。
オプション（別途検証用）
