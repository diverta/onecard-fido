# Repository diverta/onecard-fido (continued)

## EAGLE design FIDO2Device/MDBT53_Dongle/pcb_rev0/EVALBOARD_001.brd (continued)

Parts:
BAT1: BAT-HLD-012-SMT
BAT2: BAT-HLD-003-SMT
C9, C10: 1uF; C0603K
C11, C12: 4.7uF; C0603K
D2, D3, D4: PMEG2005BELD,315; DFN1006D-2
R12, R13: 0; R0603
U2: XC6206P332MR-G; SOT23

Connections:
0V: BAT1.-, BAT2.-, C9.2, C10.2, C11.2, C12.2, U2.1 (VSS); also elsewhere on the board
VBAT_1225: BAT1.+@2 (+), D3.2 (A)
VBAT_2032: BAT2.+@1 (+), D4.2 (A)
VBUS_CONN: R12.1; also elsewhere on the board
VBUS_LDO: C9.1, R12.2, U2.3 (VIN)
VDDH: C12.1, R13.2; also elsewhere on the board
VDD_3V3: C10.1, D2.2 (A), U2.2 (VOUT)
VDD_NRF: C11.1, D2.1 (C), D3.1 (C), D4.1 (C), R13.1; also elsewhere on the board

Notes on the sheet:
Eval board for MDBT53 Dongle
MDBT53 Dongle （rev0）
電源供給部
USBポートに装着時は、VBUSの5.0V-->3.3Vに降圧して供給します。 乾電池ホルダーにボタン乾電池を装着した場合は、3.0Vを供給します。
ボタン乾電池ケース（1225）
逆流回避用
ボタン乾電池ケース（2032）
バイパス用

Board: 2 copper layers, 19.9 x 99.9 mm, 47 parts (0 on the bottom side), 40 nets.

## EAGLE design FIDO2Device/BT40SlimBoard/pcb_rev1_2/SECUREBRD_003.brd

File FIDO2Device/BT40SlimBoard/README.md:

# BT40 Slim Board（rev1.1）

最新更新日：2022/6/10

## 概要

日本国内の技適取得済みであるnRF5340搭載モジュール「BT40」を使用し、Fanstel社の評価基板「[EV-BT40](https://www.mouser.jp/ProductDetail/Fanstel/EV-BT40?qs=zW32dvEIR3sMMGv%2FNMlB9A%3D%3D)」を簡略する仕様で開発・製作中の、薄型・小型基板です。

#### 特色
- 外形寸法＝3cm x 3cm
- FIDO2機能（WebAuthn）をサポート
- FIDO2機能はUSB HID／BLEの両トランスポートをサポート
- 署名検証機能付きBLEブートローダーを採用し、不正ファームウェアの書込みを抑止
- PIVカード／OpenPGPカードのエミュレーション機能を搭載
- USB給電／ボタン電池の２電源方式
- リアルタイムクロックモジュールを搭載

### [BT40 Slim Board回路図](../../FIDO2Device/BT40SlimBoard/pcb_rev1_1/SECUREBRD_002.pdf)

Fanstel社の評価基板「[EV-BT40](https://www.mouser.jp/ProductDetail/Fanstel/EV-BT40?qs=zW32dvEIR3sMMGv%2FNMlB9A%3D%3D)」をベースとし、電池電源、リアルタイムクロックモジュールの増設と、回路簡略化・配線変更を行っております。

### [nRF5340アプリケーション](../../nRF5340_app/README.md)

BT40 Slim Boardで使用するファームウェアです。

### [ファームウェア更新手順](../../MaintenanceTool/macOSApp/UPDATEFW_BLE.md)

BT40 Slim Boardのファームウェアを、[FIDO認証器管理ツール（macOS版）](../../MaintenanceTool/macOSApp)により更新する手順について説明しています。

Parts:
C1: 4.7uF; C0603K
SW1: SKRPACE010
SW2: SKTADAE010
U1: BT40; BM40-B_1PRIMARY

Connections:
0V: C1.2, SW1.3 (S), SW1.4 (S1), SW2.2 (S), SW2.4 (S1), U1.10 (GND9), U1.A0 (GND5), U1.B0 (GND6), U1.C0 (GND7), U1.D0 (GND8), U1.H0 (GND0), U1.H1 (GND1), U1.H2 (GND2), U1.H3 (GND3); also elsewhere on the board
D_N: U1.E5 (DN); also elsewhere on the board
D_P: U1.E4 (DP); also elsewhere on the board
LED1: U1.D3 (P0.28); also elsewhere on the board
LED2: U1.D4 (P0.29); also elsewhere on the board
LED3: U1.13 (P0.30); also elsewhere on the board
LED4: U1.C1 (P0.31); also elsewhere on the board
RESET: SW2.1, SW2.3 (P1), U1.14 (RESET); also elsewhere on the board
SCL: U1.2 (P1.03/SCL); also elsewhere on the board
SDA: U1.1 (P1.02/SDA); also elsewhere on the board
SW1: SW1.1, SW1.2 (P1), U1.C4 (P0.23)
SWCLK: U1.15 (SWCLK); also elsewhere on the board
SWDIO: U1.16 (SWDIO); also elsewhere on the board
TXD: U1.C5 (P0.20); also elsewhere on the board
VBUS_NRF: U1.F6 (VBUS); also elsewhere on the board
VDDH: C1.1, U1.F4 (VDDH)
VDD_NRF: U1.9 (VDD_NRF); also elsewhere on the board

Notes on the sheet:
Slim Secure Board rev1.2
BT40 Slim Board （rev1.2）
バイパスコンデンサー
リセット回路
モジュール部
MAIN SW

Parts:
C2: 0.01uF; C0402K
C3, C4: 0.1uF; C0402K
C5: 10uF; C0603K
CN1: USB4105-GF-A
D1: PRTR5V0U2X; SOT143B
L1, L2, L3, L4: BLM15AG121SN1D; C0402K
LD1: APTD1608LSECK/J4-PF; APTD1608
LD2: APHD1608LSURCK; APTD1608
LD3: APTD1608LZGCK; APTD1608
LD4: APTD1608LVBC/D; APTD1608
R1: 5.1k; R0402
R2, R3, R4: 1.2k; R0402
R5: 390; R0402

Connections:
0V: C2.2, C3.2, C4.2, C5.2, D1.1 (GND), L3.2, L4.2; also elsewhere on the board
D_N: CN1.A7 (D_N1), CN1.B7 (D_N2), D1.2 (I/O_1); also elsewhere on the board
D_P: CN1.A6 (D_P1), CN1.B6 (D_P2), D1.3 (I/O_2); also elsewhere on the board
FG: CN1.FG1, CN1.FG2, CN1.FG3, CN1.FG4, L4.1
LED1: R2.1; also elsewhere on the board
LED2: R3.1; also elsewhere on the board
LED3: R4.1; also elsewhere on the board
LED4: R5.1; also elsewhere on the board
unnamed: LD4.C, R5.2
unnamed: CN1.A5 (CC1), R1.2
unnamed: LD3.C, R4.2
unnamed: LD2.C, R3.2
unnamed: LD1.C, R2.2
USB_GND: CN1.A1 (GND1), CN1.B1 (GND2), L3.1, R1.1
VBUS: C2.1, C4.1, C5.1, CN1.A4 (VBUS1), CN1.B4 (VBUS2), D1.4 (VCC), L1.1, L2.1
VBUS_LDO: L1.2; also elsewhere on the board
VBUS_NRF: C3.1, L2.2; also elsewhere on the board
VDD_NRF: LD1.A, LD2.A, LD3.A, LD4.A; also elsewhere on the board

Notes on the sheet:
USBプラグ部
LED部
LED（黄色）
LED（赤色）
LED（緑色）
LED（青色）
USB-Cメス プラグを実装
Slim Secure Board rev1.2
BT40 Slim Board （rev1.2）

Parts:
BAT1: BAT-HLD-012-SMT
C6, C7: 1uF; C0603K
C8: 0.1uF; C0402K
CN3: IF_6PIN; HEADER_6PIN
D2, D3: PMEG2005AEA,115; SOD323-W
R6, R7, R8, R9: 10k; R0402
U2: XC6206P332MR-G; SOT23
U3: RV-3028-C7; SON-8

Connections:
0V: BAT1.-, C6.2, C7.2, C8.2, CN3.1, R8.1, R9.1, U2.1 (VSS), U3.5 (VSS); also elsewhere on the board
unnamed: C7.1, D2.A, U2.2 (VOUT)
unnamed: R9.2, U3.6 (VBACKUP)
unnamed: R8.2, U3.8 (EVI)
RESET: CN3.5; also elsewhere on the board
SCL: R7.1, U3.3 (SCL); also elsewhere on the board
SDA: R6.1, U3.4 (SDA); also elsewhere on the board
SWCLK: CN3.4; also elsewhere on the board
SWDIO: CN3.3; also elsewhere on the board
TXD: CN3.6; also elsewhere on the board
VBUS_LDO: C6.1, U2.3 (VIN); also elsewhere on the board
VDD_BAT: BAT1.+@2 (+), D3.A
VDD_NRF: C8.1, CN3.2, D2.C, D3.C, R6.2, R7.2, U3.7 (VDD); also elsewhere on the board

Notes on the sheet:
電源供給部
USBポートに装着時は、VBUSの5.0V-->3.3Vに降圧して供給します。 乾電池ホルダーにボタン乾電池を装着した場合は、3.0Vを供給します。
ボタン乾電池ケースは 基板の表面に実装
TXD: UARTデバッグ出力
時刻同期部
ボタン乾電池を装着すると、常時給電されます。
プログラミングI/F部
nRF5340アプリケーションを 書込する際に使用します。
Slim Secure Board rev1.2
BT40 Slim Board （rev1.2）

Board: 2 copper layers, 70.0 x 70.0 mm, 36 parts (0 on the bottom side), 30 nets.

## EAGLE design FIDO2Device/BT40Dongle/pcb_rev1/SECDONGL_001.brd

File FIDO2Device/BT40Dongle/README.md:

# BT40 Dongle（rev1）

最新更新日：2022/6/29

## 概要

日本国内の技適取得済みであるnRF5340搭載モジュール「BT40」を使用し、Fanstel社の評価基板「[EV-BT40](https://www.mouser.jp/ProductDetail/Fanstel/EV-BT40?qs=zW32dvEIR3sMMGv%2FNMlB9A%3D%3D)」を簡略する仕様で開発・製作中の、小型USBドングル基板です。

#### 表面

#### 裏面

#### 特色
- 外形寸法＝3.9cm x 2cm（基板外形は 3cm x 2cm）
- FIDO2機能（WebAuthn）をサポート
- FIDO2機能はUSB HID／BLEの両トランスポートをサポート
- 署名検証機能付きBLEブートローダーを採用し、不正ファームウェアの書込みを抑止
- PIVカード／OpenPGPカードのエミュレーション機能を搭載
- USB給電／ボタン電池の２電源方式
- リアルタイムクロックモジュールを搭載

### [BT40 Dongle回路図](../../FIDO2Device/BT40Dongle/pcb_rev1/SECDONGL_001.pdf)

Fanstel社の評価基板「[EV-BT40](https://www.mouser.jp/ProductDetail/Fanstel/EV-BT40?qs=zW32dvEIR3sMMGv%2FNMlB9A%3D%3D)」をベースとし、電池電源、リアルタイムクロックモジュールの増設と、回路簡略化・配線変更を行っております。

### [nRF5340アプリケーション](../../nRF5340_app/README.md)

BT40 Dongleで使用するファームウェアです。

### ファームウェア更新手順

BT40 Dongleのファームウェアを、[FIDO認証器管理ツール](../../MaintenanceTool/README.md)により更新する手順について説明しています。

- <b>[Windows版](../../MaintenanceTool/WindowsExe/UPDATEFW_BLE.md)</b>

- <b>[macOS版](../../MaintenanceTool/macOSApp/UPDATEFW_BLE.md)</b>

Parts:
C1: 4.7uF; C0603K
SW1: SKRPACE010
SW2: SKTADAE010
U1: BT40; BM40-B_1PRIMARY

Connections:
0V: C1.2, SW1.3 (S), SW1.4 (S1), SW2.2 (S), SW2.4 (S1), U1.10 (GND9), U1.A0 (GND5), U1.B0 (GND6), U1.C0 (GND7), U1.D0 (GND8), U1.H0 (GND0), U1.H1 (GND1), U1.H2 (GND2), U1.H3 (GND3); also elsewhere on the board
D_N: U1.E5 (DN); also elsewhere on the board
D_P: U1.E4 (DP); also elsewhere on the board
LED1: U1.Z3 (P1.12); also elsewhere on the board
LED2: U1.Z4 (P1.13); also elsewhere on the board
LED3: U1.Z5 (P1.14); also elsewhere on the board
LED4: U1.Z6 (P1.15); also elsewhere on the board
RESET: SW2.1, SW2.3 (P1), U1.14 (RESET); also elsewhere on the board
SCL: U1.2 (P1.03/SCL); also elsewhere on the board
SDA: U1.1 (P1.02/SDA); also elsewhere on the board
SW1: SW1.1, SW1.2 (P1), U1.C4 (P0.23)
SWCLK: U1.15 (SWCLK); also elsewhere on the board
SWDIO: U1.16 (SWDIO); also elsewhere on the board
TXD: U1.C5 (P0.20); also elsewhere on the board
VBUS_NRF: U1.F6 (VBUS); also elsewhere on the board
VDD_NRF: C1.1, U1.9 (VDD_NRF), U1.F4 (VDDH); also elsewhere on the board

Notes on the sheet:
Secure Dongle rev1
BT40 Dongle （rev1）
バイパスコンデンサー
リセット回路
モジュール部
MAIN SW

Parts:
C2: 0.01uF; C0402K
C3, C4: 0.1uF; C0402K
C5: 10uF; C0603K
CN1: CX60-24S-UNIT
CN2: IF_5PIN_H; HEADER_5PIN
D1: PRTR5V0U2X; SOT143B
L1, L2, L3: BLM15AG121SN1D; C0402K
LED1: APTD1608LSECK/J4-PF; APTD1608
LED2: APHD1608LSURCK; APTD1608
LED3: APTD1608LZGCK; APTD1608
LED4: APTD1608LVBC/D; APTD1608
R1: 5.1k; R0402
R2, R3: 1.2k; R0402
R4: 1k; R0402
R5: 390; R0402

Connections:
0V: C2.2, C3.2, C4.2, C5.2, CN2.1, D1.1 (GND), L2.2, L3.2; also elsewhere on the board
D_N: CN1.A7 (D_N), D1.2 (I/O_1); also elsewhere on the board
D_P: CN1.A6 (D_P), D1.3 (I/O_2); also elsewhere on the board
FG: CN1.AFG (FG_A), CN1.BFG (FG_B), L3.1
LED1: R2.1; also elsewhere on the board
LED2: R3.1; also elsewhere on the board
LED3: R4.1; also elsewhere on the board
LED4: R5.1; also elsewhere on the board
unnamed: LED4.C, R5.2
unnamed: CN1.A5 (CC), R1.2
unnamed: LED3.C, R4.2
unnamed: LED2.C, R3.2
unnamed: LED1.C, R2.2
RESET: CN2.5; also elsewhere on the board
SWCLK: CN2.4; also elsewhere on the board
SWDIO: CN2.3; also elsewhere on the board
USB_GND: CN1.A1 (GND1_A), CN1.A12 (GND2_A), CN1.B1 (GND1_B), CN1.B12 (GND2_B), L2.1, R1.1
VBUS: C2.1, C4.1, C5.1, CN1.A4 (VBUS1_A), CN1.A9 (VBUS2_A), CN1.B4 (VBUS1_B), CN1.B9 (VBUS2_B), D1.4 (VCC), L1.1
VBUS_NRF: C3.1, L1.2; also elsewhere on the board
VDD_NRF: CN2.2, LED1.A, LED2.A, LED3.A, LED4.A; also elsewhere on the board

Notes on the sheet:
USBプラグ部
LED部
プログラミングI/F部
nRF5340アプリケーションを 書込する際に使用します。
LED（黄色）
LED（赤色）
LED（緑色）
LED（青色）
USB-Cオス プラグを実装
Secure Dongle rev1
BT40 Dongle （rev1）

Parts:
BAT1: BAT-HLD-012-SMT
C6, C7: 1uF; C0603K
C8, C9: 0.1uF; C0402K
CN3: IF_2PIN_SOL; SOLPAD_2PIN
D2, D3: PMEG2005AEA,115; SOD323-W
R6, R7, R8: 10k; R0402
R9: 390; R0402
U2: ADP122ACPZ-3.3-R7; 6-LFCSP_UD
U3: RV-3028-C7; SON-8

Connections:
0V: BAT1.-, C6.2, C7.2, C8.2, C9.2, CN3.1, R8.1, U2.3 (GND), U3.5 (VSS); also elsewhere on the board
unnamed: C6.1, D2.A, U2.1 (VOUT)
unnamed: C9.1, R9.1, U3.6 (VBACKUP)
unnamed: R8.2, U3.8 (EVI)
SCL: R7.1, U3.3 (SCL); also elsewhere on the board
SDA: R6.1, U3.4 (SDA); also elsewhere on the board
TXD: CN3.2; also elsewhere on the board
VBUS_NRF: C7.1, U2.4 (EN), U2.6 (VIN); also elsewhere on the board
VDD_BAT: BAT1.+@2 (+), D3.A, R9.2
VDD_NRF: C8.1, D2.C, D3.C, R6.2, R7.2, U3.7 (VDD); also elsewhere on the board

Notes on the sheet:
電源供給部
USBポートに装着時は、VBUSの5.0V-->3.3Vに降圧して供給します。 乾電池ホルダーにボタン乾電池を装着した場合は、3.0Vを供給します。
ボタン乾電池ケースは 基板の裏面に実装
ユーティリティーI/F部
TXD: UARTデバッグ出力
Secure Dongle rev1
BT40 Dongle （rev1）
時刻同期部
常時給電が必要なため、ボタン乾電池に接続します。

Board: 2 copper layers, 20.4 x 30.0 mm, 37 parts (2 on the bottom side), 28 nets.

## EAGLE design FIDO2Device/MDBT50Q_Dongle_mini/pcb_rev1/SECDONGL_001.brd

File FIDO2Device/MDBT50Q_Dongle_mini/README.md:

# MDBT50Q Dongle Mini（rev1）

## 概要

日本国内の技適取得済みであるnRF52840搭載モジュール「MDBT50Q」を使用し、nRF52840 Dongleとほぼ同じ仕様で製作した、USBドングル基板です。

#### 特色
- 外形寸法＝3.9cm x 1.8cm
- FIDO2機能（WebAuthn）をサポート
- FIDO2機能はUSB HIDトランスポートをサポート
- USB給電方式（Type-Cプラグ）
- 署名検証機能付きUSBブートローダーを採用し、不正ファームウェアの書込みを抑止
- CCIDインターフェースを装備し、PIV／OpenPGPカードエミュレーションが可能
- BLEセントラルデバイスとしても動作可能

#### MDBT50Q Dongleとの比較

|項目|[MDBT50Q Dongle mini<br>(rev1)](../../FIDO2Device/MDBT50Q_Dongle_mini/pcb_rev1/README.md)|[MDBT50Q Dongle<br>(rev2.1.2)](../../FIDO2Device/MDBT50Q_Dongle/pcb_rev2_1_2/README.md)|コメント|
|:---|:---|:---|:---|
|外形寸法|3.9cm x 1.8cm|4.9cm x 1.9cm||
|給電方式|USB給電|USB給電＋ボタン電池||
|USBプラグ|Type-C|Type-A||
|Bluetoothモジュール|MDBT50Q-1MV2|MDBT50Q-P1MV2||
|セキュアIC（ATECC608A）|非搭載|搭載||
|セキュアUSBブートローダー|搭載|搭載|相違無し|
|FIDO2機能|搭載|搭載|相違無し|
|FIDO2トランスポート|USBのみ|USB／BLE|BLEはボタン電池装着時|
|スマートカードエミュレーション機能|搭載|搭載|相違無し|
|BLEセントラル機能|搭載|搭載|相違無し|

### [MDBT50Q Dongle Miniの概要](../../FIDO2Device/MDBT50Q_Dongle_mini/pcb_rev1/README.md)

基板、動作についての概要を説明しています。

### [MDBT50Q Dongle Mini回路図](../../FIDO2Device/MDBT50Q_Dongle_mini/pcb_rev1/SECDONGL_001.pdf)

nRF52840 Dongleをベースとし、LEDの増設、若干の配線変更を行っております。

### [nRF52840アプリケーション](../../nRF52840_app/README.md)

MDBT50Q Dongle Miniで使用するファームウェアです。

### [ファームウェア更新手順](../../MaintenanceTool/macOSApp/UPDATEFIRMWARE.md)

MDBT50Q Dongleのファームウェアを、[FIDO認証器管理ツール（macOS版）](../../MaintenanceTool/macOSApp)により更新する手順について説明しています。

## 動作確認手順

### [Edgeブラウザーを使用したWebAuthnテスト手順（Windows10 PC）](../../FIDO2Device/MDBT50Q_Dongle/WEBAUTHNTEST.md)

MDBT50Q Dongleと、Edgeブラウザー、デモサイトを使用して、WebAuthnのユーザー登録／ログイン（MakeCredential／GetAssertion）の動作確認をする場合の手順を掲載しています。

### [Googleアカウントのログイン確認手順（PC）](../../FIDO2Device/MDBT50Q_Dongle/PCCHROME.md)

MDBT50Q Dongleと、Googleアカウント、Chromeブラウザーを使用して、U2F Register／Authenticateの動作確認をする場合の手順を掲載しています。

### [PIN番号を使用したmacOSログイン確認手順](../../CCID/PIV/PIVPINLOGIN.md)

MDBT50Q Dongleに設定したPIV機能を使用し、PIN番号によるmacOSログインを行うための確認手順を掲載しています。

## オプション機能

BLEセントラルサービスを使用したオプション機能です。

### [BLE近接認証](../../FIDO2Device/MDBT50Q_Dongle/BLEDAUTH.md)

FIDO認証（WebAuthn／U2F）実行時、MDBT50Q Dongle上のボタンを押す代わりに、スマートフォンなどのBLEデバイスを近づけることにより、認証処理を自動的に続行させます。

Parts:
C1, C2: 12pF; C0603K
C3, C4: 4.7uF; C0603K
C5: 0.1uF; C0402K
R1: 10k; R0402
SW1: SKRPACE010
SW2: SKTADAE010
U1: MDBT50Q-P1M
X1: NX3215SA-32.768K-STD-MUA-9; NX3215

Connections:
0V: C1.2, C2.2, C3.2, C4.2, C5.2, SW1.3 (S), SW1.4 (S1), SW2.1, SW2.3 (P1), U1.1 (GND), U1.2 (GND), U1.15 (GND), U1.33 (GND), U1.55 (GND); also elsewhere on the board
D_N: U1.34 (D-); also elsewhere on the board
D_P: U1.35 (D+); also elsewhere on the board
LED1: U1.19 (P0.26); also elsewhere on the board
LED2: U1.24 (P0.08); also elsewhere on the board
LED3: U1.26 (P1.09); also elsewhere on the board
LED4: U1.29 (P0.12); also elsewhere on the board
P0.25: U1.49 (P0.25); also elsewhere on the board
P1.02: U1.50 (P1.02); also elsewhere on the board
RESET: C5.1, R1.2, SW2.2 (S), SW2.4 (S1), U1.40 (P0.18/RESET)
SW1: SW1.1, SW1.2 (P1), U1.57 (P1.06)
SWDCLK: U1.53 (SWDCLK); also elsewhere on the board
SWDIO: U1.51 (SWDIO); also elsewhere on the board
TWI_SCL: U1.11 (P0.02/AIN0); also elsewhere on the board
TWI_SDA: U1.22 (P0.06); also elsewhere on the board
VBUS_NRF: C4.1, U1.32 (VBUS); also elsewhere on the board
VDD_NRF: C3.1, R1.1, U1.28 (VDD), U1.30 (VDDH); also elsewhere on the board
XL1: C1.1, U1.17 (P0.00/XL1), X1.1
XL2: C2.1, U1.18 (P0.01/XL2), X1.2

Notes on the sheet:
32.768kHzクリスタル
バイパスコンデンサー
MDBT50Q-P1MV2 Dongle Mini rev1
(rev1)
モジュール部
リセット回路
MAIN SW
MDBT50Q Dongle Mini

Parts:
C6: 0.01uF; C0402K
C7, C8: 0.1uF; C0402K
C9: 10uF; C0603K
CN1: CX60-24S-UNIT
CN2: IF_4PIN; HEADER_4PIN
D1: PRTR5V0U2X; SOT143B
FB1, FB2, FB3: BLM15AG121SN1D; C0402K
LD1: APTD1608LSECK/J4-PF; APTD1608
LD2: APHD1608LSURCK; APTD1608
LD3: APTD1608LZGCK; APTD1608
LD4: APTD1608LVBC/D; APTD1608
R2: 5.1k; R0402
R3, R6: 1.2k; R0402
R4: 1k; R0402
R5: 390; R0402

Connections:
0V: C6.2, C7.2, C8.2, C9.2, CN2.1, D1.1 (GND), FB2.2, FB3.2; also elsewhere on the board
D_N: CN1.A7 (D_N), D1.2 (I/O_1); also elsewhere on the board
D_P: CN1.A6 (D_P), D1.3 (I/O_2); also elsewhere on the board
FG_CON: CN1.AFG (FG_A), CN1.BFG (FG_B), FB3.1
GND_CON: CN1.A1 (GND1_A), CN1.A12 (GND2_A), CN1.B1 (GND1_B), CN1.B12 (GND2_B), FB2.1, R2.1
LED1: R6.1; also elsewhere on the board
LED2: R3.1; also elsewhere on the board
LED3: R4.1; also elsewhere on the board
LED4: R5.1; also elsewhere on the board
unnamed: LD4.C, R5.2
unnamed: CN1.A5 (CC), R2.2
unnamed: LD3.C, R4.2
unnamed: LD2.C, R3.2
unnamed: LD1.C, R6.2
SWDCLK: CN2.4; also elsewhere on the board
SWDIO: CN2.3; also elsewhere on the board
VBUS: C6.1, C8.1, C9.1, CN1.A4 (VBUS1_A), CN1.A9 (VBUS2_A), CN1.B4 (VBUS1_B), CN1.B9 (VBUS2_B), D1.4 (VCC), FB1.1
VBUS_NRF: C7.1, FB1.2; also elsewhere on the board
VDD_NRF: CN2.2, LD1.A, LD2.A, LD3.A, LD4.A; also elsewhere on the board

Notes on the sheet:
USBプラグ部
LED部
プログラミングI/F部
nRF52840アプリケーションを 書込する際に使用します。
LED（黄色）
LED（赤色）
LED（緑色）
LED（青色）
MDBT50Q-P1MV2 Dongle Mini rev1
(rev1)
MDBT50Q Dongle Mini
