# Repository diverta/onecard-fido (continued)

## EAGLE design FIDO2Device/MDBT50Q_Dongle_mini/pcb_rev1/SECDONGL_001.brd (continued)

Parts:
C10, C11: 2.2uF; C0603K
C12: 0.1uF; C0402K
CN3, CN4: IF_2PIN_SOL; SOLPAD_2PIN
U2: MIC5323-3.3YMT-TR; 6-VDFN(2X2)

Connections:
0V: C10.2, C11.2, C12.2, U2.2 (GND), U2.EXP (EPAD); also elsewhere on the board
unnamed: C12.1, U2.6 (BYP)
P0.25: CN4.2; also elsewhere on the board
P1.02: CN4.1; also elsewhere on the board
TWI_SCL: CN3.1; also elsewhere on the board
TWI_SDA: CN3.2; also elsewhere on the board
VBUS_NRF: C10.1, U2.1 (EN), U2.3 (VIN); also elsewhere on the board
VDD_NRF: C11.1, U2.4 (VOUT); also elsewhere on the board

Notes on the sheet:
電源供給部
USBポートに装着時は、VBUSの5.0V-->3.3Vに降圧して供給します。
MDBT50Q-P1MV2 Dongle Mini rev1
(rev1)
MDBT50Q Dongle Mini

Board: 2 copper layers, 18.0 x 30.0 mm, 35 parts (2 on the bottom side), 28 nets.

## EAGLE design FIDO2Device/MDBT50Q_Dongle/pcb_rev2_1_1/FIDO2AUTH_00211.brd

File FIDO2Device/MDBT50Q_Dongle/README.md:

# MDBT50Q Dongle（rev2.2）

## 概要

日本国内の技適取得済みであるnRF52840搭載モジュール「MDBT50Q」を使用し、nRF52840 Dongleとほぼ同じ仕様で製作した、USBドングル基板です。

#### 特色
- 外形寸法＝5cm x 2cm
- FIDO2機能（WebAuthn）をサポート
- FIDO2機能はUSB HID／BLEの両トランスポートをサポート
- USB給電／ボタン電池の２電源方式
- リアルタイムクロック・カレンダーを搭載し、電池装着時は時刻同期が可能
- 署名検証機能付きUSBブートローダーを採用し、不正ファームウェアの書込みを抑止
- CCIDインターフェースを装備し、PIV/OpenPGPカードエミュレーション、OATH機能実行が可能

### [MDBT50Q Dongleの概要](../../FIDO2Device/MDBT50Q_Dongle/pcb_rev2_2/README.md)

基板、動作についての概要を説明しています。

### [MDBT50Q Dongle回路図](../../FIDO2Device/MDBT50Q_Dongle/pcb_rev2_2/FIDO2AUTH_0022.pdf)

nRF52840 Dongleをベースとし、電池電源の増設と、LED／RTCC（リアルタイムクロック・カレンダー）の増設、若干の配線変更を行っております。

### [nRF52840アプリケーション](../../nRF52840_app/README.md)

MDBT50Q Dongleで使用するファームウェアです。

### [ファームウェア更新手順](../../MaintenanceTool/macOSApp/UPDATEFIRMWARE.md)

MDBT50Q Dongleのファームウェアを、[FIDO認証器管理ツール](../../MaintenanceTool/README.md)により更新する手順について説明しています。

## 動作確認手順

### [Edgeブラウザーを使用したWebAuthnテスト手順（Windows10 PC）](WEBAUTHNTEST.md)

MDBT50Q Dongleと、Edgeブラウザー、デモサイトを使用して、WebAuthnのユーザー登録／ログイン（MakeCredential／GetAssertion）の動作確認をする場合の手順を掲載しています。

### [Googleアカウントのログイン確認手順（PC）](PCCHROME.md)

MDBT50Q Dongleと、Googleアカウント、Chromeブラウザーを使用して、U2F Register／Authenticateの動作確認をする場合の手順を掲載しています。

### [PIN番号を使用したmacOSログイン確認手順](../../CCID/PIV/PIVPINLOGIN.md)

MDBT50Q Dongleに設定したPIV機能を使用し、PIN番号によるmacOSログインを行うための確認手順を掲載しています。

Parts:
C1, C2: 12pF; C0603K
C3, C4: 4.7uF; C0603K
C9: 0.1uF; C0402
R1: 10k; R0402
SW1: SKRPACE010
SW2: SKTADAE010
U1: MDBT50Q-P1M
X1: NX3215SA-32.768K; NX3215

Connections:
0V: C1.2, C2.2, C3.2, C4.2, C9.2, SW1.3 (S), SW1.4 (S1), SW2.1, SW2.3 (P1), U1.1 (GND), U1.2 (GND), U1.15 (GND), U1.33 (GND), U1.55 (GND); also elsewhere on the board
D_N: U1.34 (D-); also elsewhere on the board
D_P: U1.35 (D+); also elsewhere on the board
LED1: U1.16 (P0.27); also elsewhere on the board
LED2_B: U1.29 (P0.12); also elsewhere on the board
LED2_G: U1.26 (P1.09); also elsewhere on the board
LED2_R: U1.24 (P0.08); also elsewhere on the board
LED3: U1.19 (P0.26); also elsewhere on the board
P0.25: U1.49 (P0.25); also elsewhere on the board
P1.02: U1.50 (P1.02); also elsewhere on the board
RESET: C9.1, R1.2, SW2.2 (S), SW2.4 (S1), U1.40 (P0.18/RESET)
SW1: SW1.1, SW1.2 (P1), U1.57 (P1.06)
SWDCLK: U1.53 (SWDCLK); also elsewhere on the board
SWDIO: U1.51 (SWDIO); also elsewhere on the board
TWI_SCL: U1.11 (P0.02/AIN0); also elsewhere on the board
TWI_SDA: U1.22 (P0.06); also elsewhere on the board
VBUS_NRF: C4.1, U1.32 (VBUS); also elsewhere on the board
VDD_NRF: C3.1, R1.1, U1.28 (VDD), U1.30 (VDDH); also elsewhere on the board
XL1: C1.1, U1.17 (P0.00/XL1), X1.1
XL2: C2.1, U1.18 (P0.01/XL2), X1.2

Notes on the sheet:
32.768kHzクリスタル
バイパスコンデンサー
MDBT50Q-P1M Dongle rev2.1.1
MDBT50Q Dongle （rev2.1.1）
モジュール部
リセット回路
MAIN SW

Parts:
C5: 0.01uF; C0402
C6: 10uF; C0603K
C7, C8: 0.1uF; C0402
CN1: TE-1734028
CN2: IF_4PIN; HEADER_4PIN
D1: PRTR5V0U2X; SOT143B
FB1, FB2, FB3: BLM15AG121SN1D; C0402
LD1: APHD1608LSURCK; CHIPLED_0603
LD2: APHF1608LSEEQBDZGKC
LD3: APTD1608LSYCK; CHIPLED_0603
R2, R6: 1.5k; R0402
R3: 1.2k; R0402
R4: 2.2k; R0402
R5: 390; R0402

Connections:
0V: C5.2, C6.2, C7.2, C8.2, CN2.1, D1.1 (GND), FB2.2, FB3.2; also elsewhere on the board
D_N: CN1.2 (D-), D1.2 (I/O_1); also elsewhere on the board
D_P: CN1.3 (D+), D1.3 (I/O_2); also elsewhere on the board
LED1: R2.1; also elsewhere on the board
LED2_B: R5.1; also elsewhere on the board
LED2_G: R4.1; also elsewhere on the board
LED2_R: R3.1; also elsewhere on the board
LED3: R6.1; also elsewhere on the board
unnamed: LD2.2 (CRED), R3.2
unnamed: CN1.4 (GND), FB2.1
unnamed: CN1.FG1, CN1.FG2, FB3.1
unnamed: LD2.4 (CGREEN), R4.2
unnamed: LD2.3 (CBLUE), R5.2
unnamed: LD3.C, R6.2
unnamed: LD1.C, R2.2
SWDCLK: CN2.4; also elsewhere on the board
SWDIO: CN2.3; also elsewhere on the board
VBUS: C5.1, C6.1, C8.1, CN1.1 (VBUS), D1.4 (VCC), FB1.1
VBUS_NRF: C7.1, FB1.2; also elsewhere on the board
VDD_NRF: CN2.2, LD1.A, LD2.1 (A), LD3.A; also elsewhere on the board

Notes on the sheet:
USBプラグ部
LED部
プログラミングI/F部
nRF52840アプリケーションを 書込する際に使用します。
MDBT50Q-P1M Dongle rev2.1.1
MDBT50Q Dongle （rev2.1.1）
LED（黄色）
LED（赤色）
LED（３色）

Parts:
BAT1: BAT-HLD-012-SMT
C10, C11: 1uF; C0603K
CN5: IF_2PIN_SOL; SOLPAD_2PIN
D2, D3: PMEG2005AEA,115; SOD323-W
U2: XC6206P332MR-G; SOT23

Connections:
0V: BAT1.-, C10.2, C11.2, U2.1 (VSS); also elsewhere on the board
unnamed: C11.1, D2.A, U2.2 (VOUT)
unnamed: BAT1.+@1 (+), D3.A
P0.25: CN5.2; also elsewhere on the board
P1.02: CN5.1; also elsewhere on the board
VBUS_NRF: C10.1, U2.3 (VIN); also elsewhere on the board
VDD_NRF: D2.C, D3.C; also elsewhere on the board

Notes on the sheet:
電源供給部
USBポートに装着時は、VBUSの5.0V-->3.3Vに降圧して供給します。 乾電池ホルダーにボタン乾電池を装着した場合は、3.0Vを供給します。
ボタン乾電池ケースは 基板の背面に実装
MDBT50Q-P1M Dongle rev2.1.1
MDBT50Q Dongle （rev2.1.1）

Parts:
C12: 0.1uF; C0402
R7, R8: 3.6k; R0402
U3: ATECC608A-MAHDA-S; DFN-2X3

Connections:
0V: C12.2, U3.4 (GND); also elsewhere on the board
TWI_SCL: R7.1, U3.6 (SCL); also elsewhere on the board
TWI_SDA: R8.1, U3.5 (SDA); also elsewhere on the board
VDD_NRF: C12.1, R7.2, R8.2, U3.8 (VCC); also elsewhere on the board

Notes on the sheet:
MDBT50Q-P1M Dongle rev2.1.1
MDBT50Q Dongle （rev2.1.1）
セキュリティーIC部

Board: 2 copper layers, 18.9 x 34.2 mm, 39 parts (2 on the bottom side), 30 nets.

## Commit log (part)

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2023-03-09 ドキュメントを更新
    ・CCIDドライバー修正ビルド手順書を最新内容に更新
2023-03-09 ドキュメントを更新
    ・CCIDドライバーインストール手順書を最新版に更新
2023-03-09 macOS版管理ツールのIntel mac対応
    ・バンドル格納フォルダーを管理対象外に設定
    （インストール用パッケージと重複管理になってしまうのを回避するための措置）
2023-03-10 リファクタリング
    ・外部ライブラリーの管理フォルダー体系を変更
2023-03-10 リファクタリング
    ・`.gitignore`内容の見直し
    （ビルドに使用するためのライブラリーは、外部ライブラリーの`lib`フォルダーを参照するよう修正）
2023-03-10 リファクタリング
    ・管理不要なライブラリーファイル群を削除
    （インストール用パッケージと重複管理になってしまうのを回避するための措置）
2023-03-10 ドキュメントを更新
    ・画面コピーを最新版に更新
2023-03-10 ビルド時の警告発生を回避
    ・`boxType="secondary"`により生じる警告発生を回避
    ・macOS 11.0を最小バージョン化したことに伴う警告発生を回避
2023-03-13 ドキュメントを更新
    ・バージョンに関する記述を修正
2023-03-13 TOTPメニュー画面を新設
    ・上位コマンドクラスを新設
2023-03-13 TOTPメニュー画面を新設
    ・画面項目（接続方法）を追加
2023-03-13 リファクタリング
    ・ダイアログ画面を開く処理を、`OATHCommand`から`OATHWindow`に移管
    （コマンドクラスに画面を制御させる必要がないための措置）
2023-03-13 TOTPメニュー画面を新設
    ・ラジオボタンの選択状態に応じ、トランスポート種別をパラメーターに設定
2023-03-13 TOTPメニュー画面を新設
    ・画面の機能ボタンクリック時、CCID I/F接続が可能かどうかをチェックするよう実装
2023-03-13 リファクタリング
    ・コマンドクラス／パラメーターの参照を変数化
2023-03-14 TOTPメニュー画面を新設
    ・メニュー画面を再表示時、実行機能がクリアされるよう修正
2023-03-14 認証用QRコードスキャン画面を新設
    ・画面クラスの新設
2023-03-14 認証用QRコードスキャン画面を新設
    ・認証用QRコードスキャン画面の初期表示処理を実装
    ・未搭載のOutlet／Actionを設定
2023-03-14 リファクタリング
    ・`hasScreenshotPermission`を静的呼出関数に変更
2023-03-14 認証用QRコードスキャン画面を新設
    ・QRコードスキャン事前に、画面収録の許可があるかどうかチェックするよう修正
2023-03-14 リファクタリング
    ・QRコード文字列解析用クラスの生成／初期化と、その前提となるQRコード文字列の取得処理を分離
2023-03-14 認証用QRコードスキャン画面を新設
    ・画面タイトルをプログラムで取得できるよう修正
2023-03-14 認証用QRコードスキャン画面を新設
    ・QRコードからスキャンした項目を、パラメーターに設定させるよう実装
2023-03-15 認証用QRコードスキャン画面を新設
    ・OATHアプレットSelectの処理を実装
2023-03-15 認証用QRコードスキャン画面を新設
    ・Base32デコード処理を途中まで実装
2023-03-16 認証用QRコードスキャン画面を新設
    ・アカウント登録処理用APDUの生成処理を実装
2023-03-16 リファクタリング
    ・ビルド時の警告を回避
2023-03-16 認証用QRコードスキャン画面を新設
    ・ワンタイムパスワード生成処理用APDUの生成処理を実装
2023-03-16 認証用QRコードスキャン画面を新設
    ・生成されたワンタイムパスワードを、画面表示させるよう実装
2023-03-16 認証用QRコードスキャン画面を新設
    ・認証用QRコードスキャン画面が表示中の場合、管理ツールが常に最前面に表示されるよう修正
2023-03-17 リファクタリング
    ・コマンドクラス、パラメーターの参照を保持させるよう修正
2023-03-17 リファクタリング
    ・`OATHCommand`から`OATHTotpCommand`を分離
2023-03-17 ドキュメントを更新
    ・接続仕様はnRF5340基板用なので、ドキュメント上の説明を修正
2023-03-20 TOTP処理対象アカウント選択画面を新設
    ・画面クラスを新設
2023-03-20 TOTP処理対象アカウント選択画面を新設
    ・画面のタイトル／キャプションを、機能により可変にするよう実装
2023-03-21 TOTP処理対象アカウント選択画面を新設
    ・パラメーター参照保持のタイミングを、`windowDidLoad`ではなく`windowWillOpenWithParentWindow`に修正
    （パラメーター参照が画面表示前に行われるための措置）
2023-03-21 TOTP処理対象アカウント選択画面を新設
    ・アカウント一覧から選択されたアカウントを抽出できるよう実装
    ・選択されたアカウントをパラメーターで保持
2023-03-21 TOTP処理対象アカウント選択画面を新設
    ・アカウント一覧取得処理の新設
    （内容は仮の実装です）
2023-03-21 TOTP処理対象アカウント選択画面を新設
    ・アカウント一覧取得コマンドを実行させるよう実装
2023-03-21 バグ修正
    ・アカウントが重複登録されてしまうケースが存在する不具合を解消
    （同一キーのレコードを発見した場合でも、単純に最大連番を戻してしまうための障害。同一キーのレコードに対応する連番を戻すよう修正）
2023-03-22 ワンタイムパスワード参照画面の新設
    ・画面のひな型を作成
2023-03-22 ワンタイムパスワード参照画面の新設
    ・アカウント選択後、ワンタイムパスワード生成処理に遷移させるよう実装
2023-03-22 リファクタリング
    ・コマンドクラスの参照は不要なので削除
    ・パラメーター参照を、画面表示指示があった時点で保持させるよう修正
2023-03-22 ワンタイムパスワード参照画面の新設
    ・認証器で生成されたワンタイムパスワードを画面表示させるよう実装
2023-03-22 潜在バグ修正
    ・`strlen`が正しく入力バイト数を戻さない可能性がある不具合を解消
    （上位クラスでバイト数を引数として与えるよう修正）
2023-03-22 リファクタリング
    ・Xcodeナビゲーター上のソースコード並び順を、アルファベット順に整列
2023-03-23 不要アカウント削除機能の実装
    ・OATHアカウント削除前に、確認ダイアログを表示させるよう実装
2023-03-23 不要アカウント削除機能の実装
    ・不要アカウント削除コマンドの本格実装
2023-03-23 リファクタリング
    ・`OATHTotpCommand`を`OATHAccountCommand`に吸収
    （コード量を圧縮させるための措置）
2023-03-23 リファクタリング
    ・アカウント管理処理を実行時、あらかじめ生成済みのコマンドクラスを使用させるよう修正
2023-03-23 リファクタリング
    ・関数`isUSBCCIDCanConnect`の実装を、コマンドクラス`OATHAccountCommand`に移設
2023-03-23 リファクタリング
    ・コマンドクラスの名称を`OATHAccountCommand`-->`OATHCCIDCommand`に変更
2023-03-23 SPIの追加実装
    ・リンク時のエラーを回避
2023-03-24 リファクタリング
    ・不要なヘッダーインクルードを削除
2023-03-24 SPIの追加実装
    ・TFTモジュール群を組み込み
    （デフォルト[PCA10059_03]では、使用不可としています）
2023-03-26 回路図を作成
    ・nRF52840 DK接続用治具v2の回路図
    （初版）
2023-03-27 回路図を修正
    ・回路図（PDF）を作成
2023-03-27 レイアウトを修正
    ・電源周りを配線
    ・シルクを追加（LED配線用の注記）
2023-03-27 レイアウトを修正
    ・MOSFET周りの配線レイアウトを修正
    ・ボタン乾電池の向きを修正
    （基板の最端に寄せました）
2023-03-27 レイアウトを修正
    ・LED_Gの配線
2023-03-27 レイアウトを修正
    ・LED_Rの配線
2023-03-27 レイアウトを修正
    ・テストによって差し替える可能性がある部品と、viaを離して配置させるよう修正
2023-03-27 基板製造データを作成
    ・部品表を作成
2023-03-27 基板製造データを作成
    ・実装指示書を追加
2023-03-28 機能修正
    ・HEXダンプ出力関数を追加
    （単体テスト時に使用するための措置）
2023-03-28 バグ修正
    ・オプションのフラグが不正だったため修正
2023-03-28 暗号化処理の移行（AES-256-CBC）
    ・移行完了までは、移行前テスト用のモジュールを為念で残します。
2023-03-28 暗号化処理の移行（Triple DES）
    ・Triple DESの専用関数を新設
2023-03-28 暗号化処理の移行（Triple DES）
    ・関数`triple_des_import_key`の実装
    ・定数を既存マクロで置き換え
2023-03-29 リファクタリング
    ・移行前テスト用の関数を準備
2023-03-29 暗号化処理の移行（Triple DES）
    ・`ToolPIVCommand`の復号化処理を、新設した関数で置き換え
    ・不要なヘッダーインクルードを削除
2023-03-29 調査コーディング
    ・インポートした秘密鍵／証明書ファイルから、Objective-C内部形式（`SecKeyRef`）に変換する処理のテスト
2023-03-29 リファクタリング
    ・署名生成／検証処理の部分を構造化
    （将来的に共通部品化する可能性が高いための措置）
2023-03-30 リファクタリング
    ・構造化した処理群を、モジュール`ToolSecurity`に移設
    （将来的に共通部品化する可能性が高いための措置）
2023-03-30 暗号化処理の移行（FIDO Attestation）
    ・移行済みの処理をコメントアウト
2023-03-30 調査コーディング
    ・不要な設定を削除
    （生成された鍵ペアをキーチェーンに保存する必要がないための措置）
2023-03-31 調査コーディング
    ・`SecKeyCopyExternalRepresentation`実行時エラーがログで参照できるよう修正
2023-03-31 リファクタリング
    ・EC鍵ペア生成処理を、関数`generatePrivkeyFromRandom`として`ToolSecurity`に移設
    ・`testECDH`内の公開鍵生成処理を、既存関数で置き換え
2023-03-31 リファクタリング
    ・外部表現形式への変換関数を、`getKeyFromPrivateSecKeyRef`として`ToolSecurity`に移設
2023-03-31 調査コーディング
    ・プログラム外部から取得した公開鍵バイト配列を、内部形式にリストアする処理のテスト実装
2023-03-31 リファクタリング
    ・ECDH共通鍵生成処理を、関数`generateECDHSharedSecretWithPrivate`として`ToolSecurity`に移設
2023-04-01 調査コーディング
    ・ECDH鍵交換の詳細調査に使用した調査用コードを、為念で残しておきます。
2023-04-03 対応取り消し
    ・#763 による対応前の状態に戻す
    （ECDSA処理は、OpenSSL3.0に移行させるための措置）
2023-04-03 ドキュメントを更新
    ・OpenSSL 3.0.8の導入手順書を作成
    （作成途上です）
2023-04-03 ドキュメントを更新
    ・インストールログを追加
2023-04-03 ドキュメントを更新
    ・Xcodeプロジェクト組込手順を追記
2023-04-03 暗号化処理の移行（FIDO Attestation）
    ・警告の回避（２点）
2023-04-03 バグ修正
    ・FDS GCの指示失敗時は、直ぐにレスポンスを戻すよう修正
2023-04-03 ファームウェアを更新（Version 0.3.9、PCA10059）
    ・#767 の対応による修正
    （ベンダー向け管理ツールで鍵・証明書インストール時、Flash ROM GCが実行された場合ハングしてしまう不具合を解消）
2023-04-04 バグ修正
    ・ECDHキーペア新規生成が失敗時、管理ツールがダウンしてしまう不具合を解消
    （`fido_blob_free`の実行条件を追加）
2023-04-04 暗号化処理の移行（ECDH関連）
    ・警告の回避（２点）
2023-04-04 機能修正
    ・関数`es256_sk_create`で、秘密鍵だけでなく、公開鍵も同時に生成させるよう修正
    （本件警告を多数発生させている関数`es256_derive_pk`を廃止させるための準備措置）
2023-04-04 機能修正
    ・生成したキーペアを、内部形式で保持させるよう修正
2023-04-04 リファクタリング
    ・Commit 58e1980b の対応で不要となった変数／処理を削除
2023-04-04 リファクタリング
    ・不要な構造体渡しのロジックを置き換え
2023-04-05 暗号化処理の移行（ECDH関連）
    ・関数`convert_pubkey_for_ecdh`を改修し、同関数が出していた警告を回避
2023-04-05 リファクタリング
    ・関数戻り値をboolに変更
    ・不要なヘッダーインクルードを削除
2023-04-05 リファクタリング
    ・OpenSSL関連のソースコードを、専用のフォルダーに移動
2023-04-05 リファクタリング
    ・CBOR生成処理とECDH鍵交換処理を分離させるよう修正
    ・一部の不要な関数引数を削除
2023-04-05 リファクタリング
    ・CommonCrypto関連のファイルを`common_crypto`フォルダーに集約
2023-04-05 暗号化処理の移行（鍵インポート関連）
    ・警告の回避（３点）
2023-04-06 リファクタリング
    ・CBOR生成処理とHMAC処理を分離させるよう修正
    ・一部の不要な関数引数を削除
    ・HMAC処理を内包するClientPin関連関数を、モジュール`fido_client_pin`に集約させるよう修正
2023-04-06 リファクタリング
    ・CBOR生成処理とHMAC処理を分離させるよう修正
    ・一部不足している関数引数を追加
2023-04-07 暗号化処理の移行（HMAC関連）
    ・関数`generate_pin_auth_from_client_data`を改修し、同関数が出していた警告を回避
    ・`generate_pin_auth_from_client_data`の処理失敗時に、詳細ログを出力させるよう修正
2023-04-07 ドキュメントを更新
    ・OATH機能のリンクを追加
2023-04-07 TFTライブラリーの移行
    ・元から存在する`spi4`を使用するよう修正
    ・`spi2`は不要なので削除
2023-04-07 TFTライブラリーの移行
    ・非推奨マクロを、推奨マクロに置き換え
    ・推奨マクロにあわせてコードを修正
    ・不要なマクロ定義を削除
2023-04-07 TFTライブラリーの移行
    ・`app_tiny_tft_delay_ms`を廃止
    （ラッパー関数で置き換え）
2023-04-07 TFTライブラリーの移行
    ・コマンド／データ送信処理部分を、ラッパー関数に切り出して移設
2023-04-10 TFTライブラリーの移行
    ・リセットピン処理部分を、ラッパー関数に切り出して移設
    ・リセットロジックの最適化
2023-04-10 ドキュメントを更新
    ・本件対応におけるモジュール構成変更内容を反映
2023-04-10 暗号化関連の初期化処理を直列化
    ・ランダムシード生成完了／ランダムベクター生成完了の各イベントを分割させ、個別にハンドリングできるよう修正
2023-04-10 暗号化関連の初期化処理を直列化
    ・`data_channel_initialized`の実行時点を直列化
2023-04-10 機能修正
    ・RTCCのバックアップレジスター書き換え処理の不要判定が間違っていたため修正
    （Commit 1613c08e の、nRF52840アプリケーションへの横展開）
    ・一部のログ出力処理を修正
2023-04-11 事前準備
    ・同梱ファームウェアを更新
2023-04-11 ドキュメントを更新
    ・画面イメージを最新版に更新
2023-04-11 バージョン更改（0.2.5、macOS版管理ツール[Apple silicon]）
    ・OATH-TOTP機能を追加
    ・バグ修正（Commit d1309834）
    ・同梱ファームウェアを更新（Version 0.3.9、PCA10059）
    ・macOS 11.0以降のバージョンに対応（10.15以前のバージョンには対応しません）
2023-04-12 文字列データの妥当性チェック対応
    ・アカウント一覧のアカウント名が、表示可能文字列かどうかのチェックを行うよう修正
2023-04-12 ドキュメントを更新
    ・画面収録許可の設定手順書を作成
2023-04-12 ドキュメントを更新
    ・OATH機能設定手順書を追加
    （まだ記述途上です。）
    ・画面収録許可の設定手順書へリンク
2023-04-12 ドキュメントを更新
    ・画面イメージを最新版に更新
    ・認証器リセット手順の記述を`PGPSETTING_OPT.md`に移す
2023-04-13 ドキュメントを更新
    ・PIV関連の手順／開発ドキュメントを、`CCID/PIV`フォルダー配下に集約
2023-04-13 ドキュメントを更新
    ・画面イメージを最新版に更新
    ・ファームウェア再起動手順を修正
2023-04-13 バージョン更改（0.3.2、Windows版管理ツール）
    ・OATH-TOTP機能を追加
    ・同梱ファームウェアを更新（Version 0.3.9、PCA10059）
2023-04-13 リファクタリング
    ・#773 の移行内容を横展開
    （ラッパーモジュール`tiny_tft_base.c`を新設）
2023-04-14 機能修正
    ・バックライトLEDの制御を追加
2023-04-17 SPIの追加実装
    ・バックライトLED制御関数の追加実装
    （Commit 8b49edf0 の横展開）
2023-04-17 SPIの追加実装
    ・送信タイムアウトが検出できるよう修正
    （１秒経過後に応答無しの場合、タイムアウトと判定）
2023-04-17 機能修正
    ・TFTモジュール初期化処理を、アプリケーション始動前に行わないよう修正
    （メッセージ出力のみにとどめる）
2023-04-17 リファクタリング
    ・一部マクロを、処理内容の実態に即した名称に変更
2023-04-17 ドキュメントを更新
    ・TFT接続対応のポータルを更新
2023-04-17 TFT初期化処理の修正
    ・TFTモジュールが利用できるかどうかを照会する関数の新設
2023-04-17 TFT初期化処理の修正
    ・TFTモジュール初期化処理を、アプリケーション始動前に実行させるよう修正
2023-04-17 ドキュメントを更新
    ・ポータルページの記述構成を見直し
2023-04-18 ドキュメントを更新
    ・モジュール一覧を最新内容に更新
2023-04-18 TFT初期化処理の修正
    ・TFTモジュール初期化処理を、アプリケーション始動前に実行させるよう修正
    （Commit 17a9fe2a の横展開）
2023-04-18 ドキュメントを更新
    ・写真を最新の内容に更新
2023-04-18 ペアリングモード起動判定ロジックの修正
    ・nRF5340に登録されているペアリング情報数をカウントアップするロジックの新設
2023-04-18 機能修正
    ・ペアリングモード時は黄色LEDを連続点灯させるよう修正
2023-04-18 ペアリングモード起動判定ロジックの修正
    ・ペアリングモードで起動した場合、無通信タイムアウトを60秒とする
2023-04-18 リファクタリング
    ・Commit 840b84e3 の対応により、不要となった処理を削除
2023-04-18 ペアリングモード起動判定ロジックの修正
    ・ペアリングモードのタイムアウトを、プロジェクト設定`CONFIG_BT_LIM_ADV_TIMEOUT`と整合させるよう修正
    （設定値は 90秒）
2023-04-19 サービスデータフィールド追加対応
    ・BLE SMPサービスUUIDのアドバタイズを、非ペアリングモード時に限定
    （サービスデータフィールドをアドバタイズデータに含める際、全体で31バイトに収める必要があるための措置）
2023-04-19 バグ修正
    ・ペアリングモード時にタイムアウト監視が延長されてしまう不具合を解消
    （Commit 1c7391da のデグレード。ペアリングモード時はタイマーをリセットさせないよう修正）
2023-04-19 ペアリング解除要求コマンドの実装
    ・コマンド冒頭で現在接続中デバイスのBluetoothアドレスを取得
2023-04-19 ペアリング解除要求コマンドの実装
    ・ペアリング解除要求コマンドの応答ロジックまで実装
2023-04-19 ペアリング解除要求コマンドの実装
    ・PCでのペアリング情報削除後の切断検知ロジックを追加
    ・nRF52840アプリケーションと同様、ペアリング解除要求が成功時は、スリープ状態に遷移させるよう実装
2023-04-20 ペアリング解除要求コマンドの実装
    ・ペアリング解除要求関連処理を、モジュール`app_ble_unpairing`に移設
2023-04-20 リファクタリング
    ・ペアリング情報削除処理を、モジュール`app_ble_unpairing`に移設
    （関数名も変更）
2023-04-20 バグ修正
    ・複数端末でペアリングを実行させた場合に、ペアリング情報削除処理がハングしてしまう不具合を解消
    （プラットフォームAPIの不具合による障害。不具合箇所を回避したコードを、nRF5340アプリケーション内に再実装）
2023-04-20 バグ修正
    ・タイムアウトを、ペアリングモード時＝90秒に設定させるよう修正
    （Commit 9aed70c のデグレード。ペアリングモード時の最大アドバタイズ期間に合わせて90秒に設定）
2023-04-20 バグ修正
    ・コールバック設定処理がペアリングモード切り替えの度に行われる不具合を解消
    （コールバック設定処理が、アプリケーション初期化の段階で１度だけ行われるよう修正）
2023-04-21 バグ修正
    ・ペアリング情報がないPCからペアリング解除要求を実行時、パスコード入力画面が表示されてしまう不具合を解消
    （nRF5340側から、非ペアリングモード時のペアリング要求を拒絶するよう修正）
2023-04-24 BLEアドバタイズ停止機能の実装
    ・ペアリング障害をメインスレッドに通知できるよう実装
2023-04-24 リファクタリング
    ・アドバタイズ関連処理を、モジュール`app_ble_advertise`に集約
2023-04-24 リファクタリング
    ・新設モジュール`app_ble_advertise`の関数に置き換え
2023-04-24 BLEアドバタイズ停止機能の実装
    ・アドバタイズを開始する処理の実装
    （Commit c909c624 で一旦削除した処理を再実装）
2023-04-24 リファクタリング
    ・不要となった関数を削除
2023-04-24 BLEアドバタイズ停止機能の実装
    ・ペアリング障害時にボタン短押しでペアリングモードへ遷移できるよう実装
2023-04-24 BLEアドバタイズ停止機能の実装
    ・ペアリング情報消失検知時、メインスレッドに通知されるよう実装
2023-04-24 リファクタリング
    ・接続関連処理を、専用モジュール`app_ble_connection`に移設
2023-04-24 リファクタリング
    ・`app_bluetooth`と`app_ble_smp`を、モジュール`app_ble_init`に統合
2023-04-25 バグ修正
    ・接続障害発生時、以降のBLEペアリングが実行されない不具合を解消
    （スキャン完了後、GATT接続されなかったケースで、スキャン完了時に保持した接続済みペリフェラル参照が残ってしまうための障害。エラー検知と同時に、接続済みペリフェラル参照をクリアさせるよう修正）
2023-04-25 ボタンによる電源On/Off制御の実装
    ・ファームウェア始動時に、USB接続が検出されなかった場合、スリープ状態に遷移させるよう実装
2023-04-25 ボタンによる電源On/Off制御の実装
    ・ラッパー関数の実装
    （ペアリング時のパスコード入力画面、ペアリング解除要求画面表示中に、基板上のボタンを押しても無視させるようにするためのフラグを設定する関数）
2023-04-25 ボタンによる電源On/Off制御の実装
    ・ペアリング処理完了時に、ボタン押下抑止を解除するよう実装
2023-04-26 セキュアブートローダーの移行
    ・差分を反映
2023-04-26 セキュアブートローダーの移行
    ・イメージ反映所要時間を８秒延長
2023-04-26 バグ修正
    ・リセット実行前に接続断検知をした場合、制御が戻らずタイムアウト（150秒）まで待たされてしまう不具合を解消
2023-04-26 セキュアブートローダーの移行
    ・イメージ反映所要時間を８秒延長
    ・`MaintenanceTool.csproj`から不要な要素を削除
2023-04-27 ドキュメントを更新
    ・ポータルを更新
    （開発途上のnRF5340関連のリンクは外す）
2023-04-27 ドキュメントを更新
    ・基板についての説明を修正
2023-04-27 ドキュメントを更新
    ・対応環境についての記述を修正
