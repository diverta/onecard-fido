# Repository diverta/onecard-fido

## EAGLE design FIDO2Device/MDBT50Q_Dongle/pcb_rev1/FIDO2AUTH_001.brd

Board: 2 copper layers, 22.9 x 38.7 mm, 33 parts (1 on the bottom side), 26 nets.

Parts:
BAT1: BAT-HLD-012-SMT
C1, C2: 12pF; C0603K
C3, C4: 4.7uF; C0603K
C5: 0.01uF; C0603K
C6: 10uF; C0603K
C7, C8, C9: 0.1uF; C0603K
C10, C11: 1uF; C0603K
CN1: TE-1734028
CN2: IF_5PIN_H; HEADER_5PIN
CN3: IF_3PIN; HEADER_3PIN
D1: PRTR5V0U2X; SOT143B
D2, D3: PMEG2005AEA,115; SOD323-W
FB1, FB2, FB3: BLM15AG121SN1D; C0402K@1
LED1: APHD1608LSURCK; CHIPLED_0603
LED2: APHF1608LSEEQBDZGKC
R1: 10k; R0603
R2: 1.5k; R0603
R3: 1.2k; R0603
R4: 2.2k; R0603
R5: 390; R0603
SW1: SKRPACE010
SW2: SKTADAE010
U1: MDBT50Q-P1M
U2: XC6206P332MR-G; SOT23
X1: NX3215SA-32.768K; NX3215

Connections:
0V: BAT1.-, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, CN2.1, CN3.1, D1.1, FB2.2, FB3.2, SW1.3, SW1.4, SW2.1, SW2.3, U1.1, U1.2, U1.15, U1.33, U1.55, U2.1
AIN0: CN3.2, U1.11
AIN1: CN3.3, U1.9
D_N: CN1.2, D1.2, U1.34
D_P: CN1.3, D1.3, U1.35
LED1: R2.1, U1.22
LED2_B: R5.1, U1.29
LED2_G: R4.1, U1.26
LED2_R: R3.1, U1.24
unnamed: LED2.2, R3.2
unnamed: CN1.4, FB2.1
unnamed: CN1.FG1, CN1.FG2, FB3.1
unnamed: C11.1, D2.A, U2.2
unnamed: BAT1.+@1, D3.A
unnamed: LED2.4, R4.2
unnamed: LED2.3, R5.2
unnamed: LED1.C, R2.2
RESET: C9.1, CN2.5, R1.2, SW2.2, SW2.4, U1.40
SW1: SW1.1, SW1.2, U1.57
SWDCLK: CN2.3, U1.53
SWDIO: CN2.2, U1.51
VBUS: C5.1, C6.1, C8.1, CN1.1, D1.4, FB1.1
VBUS_NRF: C4.1, C7.1, C10.1, FB1.2, U1.32, U2.3
VDD_NRF: C3.1, CN2.4, D2.C, D3.C, LED1.A, LED2.1, R1.1, U1.28, U1.30
XL1: C1.1, U1.17, X1.1
XL2: C2.1, U1.18, X1.2

## EAGLE design U2FHIDDevice/pcb/U2FHIDDevice_0.brd

Parts:
C1, C2: 2.7pF; C0603K
R1, R2: 0; R0603
R3, R4: 10k; R0603
U1: STM32F411RET6_; LQFP64-10X10_DEV
X1: NX3215SA_; NX3215_DEV

Connections:
0V: C1.2, C2.2, R3.2, U1.18 (VSS), U1.31 (VSS1), U1.47 (VSS2), U1.63 (VSS3); also elsewhere on the board
AGND: U1.12 (VSSA/VREF-); also elsewhere on the board
AVDD: U1.13 (VDDA/VREF+); also elsewhere on the board
BOOT0: R3.1, U1.60 (BOOT0)
LED_BLUE: U1.22 (PA6); also elsewhere on the board
LED_GREEN: U1.21 (PA5); also elsewhere on the board
unnamed: C1.1, R1.1, X1.1
unnamed: C2.1, R2.1, X1.2
NRST: U1.7 (NRST); also elsewhere on the board
OSC32_IN: R1.2, U1.3 (PC14-OSC32_IN)
OSC32_OUT: R2.2, U1.4 (PC15-OSC32_OUT)
SWO: U1.55 (PB3); also elsewhere on the board
TCK: U1.49 (PA14); also elsewhere on the board
TMS: U1.46 (PA13); also elsewhere on the board
USART_RX: U1.17 (PA3); also elsewhere on the board
USART_TX: U1.16 (PA2); also elsewhere on the board
USB_DM: U1.44 (PA11); also elsewhere on the board
USB_DP: U1.45 (PA12); also elsewhere on the board
USER_BUTTON: R4.1, U1.2 (PC13)
VCAP_1: U1.30 (VCAP_1); also elsewhere on the board
VDD: R4.2, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD1), U1.48 (VDD2), U1.64 (VDD3); also elsewhere on the board

Notes on the sheet:
U2F USB HIDデバイス
試作基板回路図 Ver. 0.0

Parts:
C3, C5, C11: 1uF; C0603K
C4, C6, C7, C8, C9, C10, C13: 0.1uF; C0603K
C12: 4.7uF; C1206
L1: BLM18EG601SN1D; R0603
R5: 0; R0603
U2: LD39050PU33R_DEV; DFN6-3X3_DEV

Connections:
0V: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, R5.1, U2.2 (GND), U2.EXP (GND0); also elsewhere on the board
AGND: C13.2, R5.2; also elsewhere on the board
AVDD: C13.1, L1.2; also elsewhere on the board
U5V: C3.1, C4.1, U2.1 (EN), U2.6 (VIN); also elsewhere on the board
VCAP_1: C12.1; also elsewhere on the board
VDD: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, L1.1, U2.4 (VOUT); also elsewhere on the board

Notes on the sheet:
電源回路
U2F USB HIDデバイス
試作基板回路図 Ver. 0.0
1uFはVBATの 近傍に配置

Parts:
C14, C15: 0.1uF; C0603K
CN1: TE-1734028
CN2: IF_7PIN; HEADER_7PIN
D1: APTD1608LCGCK; CHIPLED_0603
D2: APHD1608LQBC/D; CHIPLED_0603
R6: 1k; R0603
R7: 680; R0603
SW1: SKRPACE010
U3: USBLC6-2SC6; SOT23-6L

Connections:
0V: C14.2, C15.2, CN1.FG1, CN1.FG2, CN1.P$4 (GND), CN2.2, D1.C, D2.C, SW1.3 (S), SW1.4 (S1), U3.2 (GND); also elsewhere on the board
LED_BLUE: R7.1; also elsewhere on the board
LED_GREEN: R6.1; also elsewhere on the board
unnamed: D1.A, R6.2
unnamed: D2.A, R7.2
NRST: C15.1, CN2.4, SW1.1, SW1.2 (P1); also elsewhere on the board
SWO: CN2.5; also elsewhere on the board
TCK: CN2.1; also elsewhere on the board
TMS: CN2.3; also elsewhere on the board
U5V: C14.1, CN1.P$1 (VBUS), U3.5 (VBUS); also elsewhere on the board
UDM: CN1.P$2 (D-), U3.3 (I/O2)
UDP: CN1.P$3 (D+), U3.1 (I/O1)
USART_RX: CN2.7; also elsewhere on the board
USART_TX: CN2.6; also elsewhere on the board
USB_DM: U3.4 (I/O2_O); also elsewhere on the board
USB_DP: U3.6 (I/O1_O); also elsewhere on the board

Notes on the sheet:
ユーザーLED （緑色・青色）
リセットボタン
ESD保護回路
USBプラグ（type A）
ファームウェア書込 ／デバッグ用回路
NUCLEOに付属の ST-LINK V2-1に接続します
U2F USB HIDデバイス
試作基板回路図 Ver. 0.0
TCK
GND
TMS
NRST
SWO
ST-LINK RX
ST-LINK TX

Board: 2 copper layers, 45.7 x 22.9 mm, 32 parts (0 on the bottom side), 26 nets.

## EAGLE design U2FHIDDevice/pcb/U2FHIDDevice_1.brd

Parts:
C1, C2: 2.7pF; C0603K
C3, C4: 4.3pF; C0603K
R1: 10k; R0603
R2: 4.7k; R0603
U1: STM32F411RET6_; LQFP64-10X10_DEV
X1: NX3215SA_; NX3215_DEV
X2: NX3225GD_; NX3225_DEV

Connections:
0V: C1.2, C2.2, C3.2, C4.2, R1.2, U1.18 (VSS), U1.31 (VSS1), U1.47 (VSS2), U1.63 (VSS3); also elsewhere on the board
AGND: U1.12 (VSSA/VREF-); also elsewhere on the board
AVDD: U1.13 (VDDA/VREF+); also elsewhere on the board
BOOT0: R1.1, U1.60 (BOOT0)
LED_BLUE: U1.22 (PA6); also elsewhere on the board
LED_GREEN: U1.21 (PA5); also elsewhere on the board
NRST: U1.7 (NRST); also elsewhere on the board
OSC32_IN: C1.1, U1.3 (PC14-OSC32_IN), X1.1
OSC32_OUT: C2.1, U1.4 (PC15-OSC32_OUT), X1.2
OSC_IN: C3.1, U1.5 (PH0-OSC_IN), X2.1
OSC_OUT: C4.1, U1.6 (PH1-OSC_OUT), X2.2
SWO: U1.55 (PB3); also elsewhere on the board
TCK: U1.49 (PA14); also elsewhere on the board
TMS: U1.46 (PA13); also elsewhere on the board
USART_RX: U1.17 (PA3); also elsewhere on the board
USART_TX: U1.16 (PA2); also elsewhere on the board
USB_DM: U1.44 (PA11); also elsewhere on the board
USB_DP: U1.45 (PA12); also elsewhere on the board
USER_BUTTON: R2.1, U1.2 (PC13); also elsewhere on the board
VCAP_1: U1.30 (VCAP_1); also elsewhere on the board
VDD: R2.2, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD1), U1.48 (VDD2), U1.64 (VDD3); also elsewhere on the board

Notes on the sheet:
U2F USB HIDデバイス
試作基板回路図 Ver. 0.1

Parts:
C5, C7, C13: 1uF; C0603K
C6, C8, C9, C10, C11, C12, C15: 0.1uF; C0603K
C14: 4.7uF; C1206
L1: BLM18EG601SN1D; R0603
R3: 0; R0603
U2: LD39050PU33R_DEV; DFN6-3X3_DEV

Connections:
0V: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, R3.1, U2.2 (GND), U2.EXP (GND0); also elsewhere on the board
AGND: C15.2, R3.2; also elsewhere on the board
AVDD: C15.1, L1.2; also elsewhere on the board
U5V: C5.1, C6.1, U2.1 (EN), U2.6 (VIN); also elsewhere on the board
VCAP_1: C14.1; also elsewhere on the board
VDD: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, L1.1, U2.4 (VOUT); also elsewhere on the board

Notes on the sheet:
電源回路
U2F USB HIDデバイス
試作基板回路図 Ver. 0.1
1uFはVBATの 近傍に配置

Parts:
C16, C17, C18: 0.1uF; C0603K
CN1: TE-1734028
CN2: IF_7PIN; HEADER_7PIN
D1: APTD1608LCGCK; CHIPLED_0603
D2: APHD1608LQBC/D; CHIPLED_0603
R4: 1k; R0603
R5: 680; R0603
R6: 100; R0603
SW1, SW2: SKRPACE010
U3: USBLC6-2SC6; SOT23-6L

Connections:
0V: C16.2, C17.2, CN1.FG1, CN1.FG2, CN1.P$4 (GND), CN2.2, D1.C, D2.C, R6.2, SW1.3 (S), SW1.4 (S1), SW2.3 (S), SW2.4 (S1), U3.2 (GND); also elsewhere on the board
LED_BLUE: R5.1; also elsewhere on the board
LED_GREEN: R4.1; also elsewhere on the board
unnamed: D1.A, R4.2
unnamed: C18.2, R6.1
unnamed: D2.A, R5.2
NRST: C17.1, CN2.4, SW1.1, SW1.2 (P1); also elsewhere on the board
SWO: CN2.5; also elsewhere on the board
TCK: CN2.1; also elsewhere on the board
TMS: CN2.3; also elsewhere on the board
U5V: C16.1, CN1.P$1 (VBUS), U3.5 (VBUS); also elsewhere on the board
UDM: CN1.P$2 (D-), U3.3 (I/O2)
UDP: CN1.P$3 (D+), U3.1 (I/O1)
USART_RX: CN2.7; also elsewhere on the board
USART_TX: CN2.6; also elsewhere on the board
USB_DM: U3.4 (I/O2_O); also elsewhere on the board
USB_DP: U3.6 (I/O1_O); also elsewhere on the board
USER_BUTTON: C18.1, SW2.1, SW2.2 (P1); also elsewhere on the board

Notes on the sheet:
ユーザーLED （緑色・青色）
リセットボタン
ESD保護回路
USBプラグ（type A）
ファームウェア書込 ／デバッグ用回路
NUCLEOに付属の ST-LINK V2-1に接続します
U2F USB HIDデバイス
試作基板回路図 Ver. 0.1
TCK
GND
TMS
NRST
SWO
ST-LINK RX
ST-LINK TX
ユーザーボタン

Board: 2 copper layers, 45.7 x 22.9 mm, 36 parts (0 on the bottom side), 27 nets.
